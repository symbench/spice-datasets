.title KiCad schematic
UG8 /C2M /HCTRRST /CNT0 /CNT1 /CNT2 /CNT3 NC_01 /CNT6 /CNT5 /CNT4 /HCTRRST /CNT3 LS393
UG6 C16M /VADR_0_ /VADR_1_ /VADR_2_ /VADR_3_ /VADR_4_ /VADR_5_ /VADR_7_ NC_02 NC_03 /VIDTIME NC_04 NC_05 /LCTRRST NC_06 NC_07 NC_08 NC_09 PAL16R8B
UF8 /TWOLINE /LCTRRST /VADR_0_ /VADR_1_ /VADR_2_ /VADR_3_ /VADR_7_ VADR_6_ /VADR_5_ /VADR_4_ /LCTRRST /VADR_3_ LS393
UE7 C16M NC_10 HSYNC* NC_11 NC_12 NC_13 NC_14 NC_15 /VIDTIME NC_16 /VID-V NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 PAL16R8B
UD8 Net-_UA8-Pad1_ /VID-V NC_24 NC_25 /VADR_1_ Net-_UA8-Pad1_ /RA_0_ Net-_UA8-Pad1_ /RA_1_ Net-_UA8-Pad1_ /VADR_2_ NC_26 NC_27 /VIDMUX* Net-_UA8-Pad1_ Net-_UA8-Pad16_ 74F253
UC8 Net-_UA8-Pad1_ /VID-V NC_28 NC_29 /VADR_3_ Net-_UA8-Pad1_ /RA_2_ Net-_UA8-Pad1_ /RA_3_ Net-_UA8-Pad1_ /VADR_4_ NC_30 NC_31 /VIDMUX* Net-_UA8-Pad1_ Net-_UA8-Pad16_ 74F253
UB8 Net-_UA8-Pad1_ /VID-V NC_32 NC_33 /VADR_5_ Net-_UA8-Pad1_ /RA_4_ Net-_UA8-Pad1_ /RA_5_ Net-_UA8-Pad1_ VADR_6_ NC_34 NC_35 /VIDMUX* Net-_UA8-Pad1_ Net-_UA8-Pad16_ 74F253
UA8 Net-_UA8-Pad1_ /VID-V NC_36 NC_37 /VADR_7_ /TWOLINE /RA_6_ Net-_UA8-Pad1_ /RA_7_ /VADR_0_ NC_38 NC_39 NC_40 /VIDMUX* Net-_UA8-Pad1_ Net-_UA8-Pad16_ 74F253
UC7 /SC.F NC_41 NC_42 /DT-OE* NC_43 NC_44 /VIDW* /VIDRAS* /RA_6_ /RA_5_ /RA_4_ Net-_UC6-Pad12_ /RA_7_ /RA_3_ /RA_2_ /RA_1_ /RA_0_ /VIDCAS* NC_45 NC_46 PD11 NC_47 NC_48 Net-_UC6-Pad24_ D41264C-12
UC6 /SC.F NC_49 NC_50 /DT-OE* NC_51 NC_52 /VIDW* /VIDRAS* /RA_6_ /RA_5_ /RA_4_ Net-_UC6-Pad12_ /RA_7_ /RA_3_ /RA_2_ /RA_1_ /RA_0_ /VIDCAS* NC_53 NC_54 PD11 NC_55 NC_56 Net-_UC6-Pad24_ D41264C-12
UG7 C16M /CNT0 /CNT1 /CNT2 /CNT3 /CNT4 /CNT5 /CNT6 /VIDTIME NC_57 /TWOLINE HSYNC* NC_58 NC_59 /C2M NC_60 NC_61 /HCTRRST PAL16R8B
.end
