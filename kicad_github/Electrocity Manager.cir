.title KiCad schematic
U3 +3.3V NC_01 NC_02 NC_03 /OSC_IN /OSC_OUT /~NRST NC_04 NC_05 NC_06 NC_07 GND +3.3V NC_08 NC_09 NC_10 NC_11 GND +3.3V NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 Net-_C13-Pad1_ +3.3V NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 /SWDIO Net-_C15-Pad1_ +3.3V /SWCLK NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 Net-_R9-Pad1_ NC_46 NC_47 GND +3.3V STM32F405RG
C9 GND +3.3V 4.7u
C10 GND +3.3V 0.1u
C12 GND +3.3V 0.1u
C14 GND +3.3V 0.1u
C16 GND +3.3V 1u
R9 Net-_R9-Pad1_ GND 10k
JP1 Net-_D1-Pad1_ Net-_JP1-Pad2_ 3.3V_JP
D1 Net-_D1-Pad1_ +3.3V DIODE
U5 GND +3.3V +5V AZ1086H
C11 +5V GND 10u
C18 +3.3V GND 22u
C15 Net-_C15-Pad1_ GND 2.2u
C13 Net-_C13-Pad1_ GND 2.2u
X1 /OSC_IN /OSC_OUT 8MHz
C1 /OSC_IN GND 22p
C3 /OSC_OUT GND 22p
U1 NC_48 GND +3.3V NC_49 NC_50 /CAN0_L /CAN0_H Net-_R12-Pad2_ MAX3051
C4 GND +3.3V 0.1u
R12 GND Net-_R12-Pad2_ R_JP
P2 GND +12V /CAN0_H /CAN0_L CAN0
C7 GND +12V 0.1u
P4 GND +12V /CAN0_H /CAN0_L CAN0
C17 GND +12V 0.1u
R20 Net-_JP2-Pad1_ /CAN0_H 120
JP2 Net-_JP2-Pad1_ /CAN0_L CAN0_JP
P1 GND Net-_JP1-Pad2_ /SWCLK /SWDIO /~NRST NC_51 SWD
U6 GNDPWR GNDPWR Main_Power GND NC_52 12V_Current_Out CCG30-24-12S
D2 Net-_D2-Pad1_ GND LED
D3 Net-_D3-Pad1_ GND LED
D4 Net-_D4-Pad1_ GND LED
R3 Net-_D2-Pad1_ +12V 1.2k
R4 Net-_D3-Pad1_ +5V 510
R5 Net-_D4-Pad1_ +3.3V 330
P14 GNDPWR +BATT BATT_IN
P15 GNDPWR To_MD POWER_OUT
P16 GNDPWR To_Fun FUN_OUT
P17 GNDPWR FRAME_GND
P11 24V Main_Power Main_SW
D22 +BATT 24V DIODE
P12 +12P Net-_P12-Pad2_ EMERGENCY
P13 Net-_P12-Pad2_ Coil_IN EMERGENCY
U4 Net-_R16-Pad1_ Net-_R17-Pad1_ Net-_R18-Pad1_ GND GND GND OSTBABS4C2B
R16 Net-_R16-Pad1_ NC_53 330
R17 Net-_R17-Pad1_ NC_54 330
R18 Net-_R18-Pad1_ NC_55 330
SP1 +3.3V Net-_D14-Pad1_ SPEAKER
D14 Net-_D14-Pad1_ +3.3V DIODE
Q1 Net-_Q1-Pad1_ GND Net-_D14-Pad1_ NPN
R19 Net-_Q1-Pad1_ /TIMx_CHx 10
U13 +3.3V GND Net-_R41-Pad2_ CurrentSensor_IN1 To_Fun ACS781
IC1 Relay_Out Net-_IC1-Pad2_ /Relay_State +3.3V TLP291
C35 GND +3.3V 0.1u
R41 /ADC12_INx Net-_R41-Pad2_ R
C37 GND /ADC12_INx 0.1u
U12 +3.3V GND Net-_R40-Pad2_ CurrentSensor_IN0 To_MD ACS781
C34 GND +3.3V 0.1u
R40 /ADC12_INx Net-_R40-Pad2_ R
C36 GND /ADC12_INx 0.1u
SW1 GND /PXx SW0
R1 +5V /PXx 10k
SW3 GND /PXx SW1
R2 +5V /PXx 10k
SW4 GND /PXx SW2
R6 +5V /PXx 10k
R7 /PXx Net-_D5-Pad1_ 330
D5 Net-_D5-Pad1_ GND LED0
R8 /PXx Net-_D6-Pad1_ 330
D6 Net-_D6-Pad1_ GND LED1
P3 GND +5V NC_56 NC_57 SERIAL0
C8 GND +5V 0.1u
R10 /PXx Net-_D7-Pad1_ 330
D7 Net-_D7-Pad1_ GND LED2
R11 /PXx Net-_D8-Pad1_ 330
D8 Net-_D8-Pad1_ GND LED3
R13 /PXx Net-_D9-Pad1_ 330
D9 Net-_D9-Pad1_ GND LED4
U7 NC_58 NC_59 Net-_C29-Pad1_ Net-_C29-Pad2_ +3.3V GND /I2C_SDA /I2C_SCL NC_60 +3.3V Net-_R24-Pad1_ AQM1602_BL
C29 Net-_C29-Pad1_ Net-_C29-Pad2_ 1u
R22 +3.3V /I2C_SDA 10k
R21 +3.3V /I2C_SCL 10k
Q2 Net-_Q2-PadD_ Net-_Q2-PadG_ GND MOSFET_N
R24 Net-_R24-Pad1_ Net-_Q2-PadD_ R
R23 Net-_Q2-PadG_ /TIMx_CHx 10
C28 GND +3.3V 0.1u
SW2 /~NRST GND RESET
C2 GND /~NRST C
P5 GND +12V 12V_Out
P7 GND +12V /Force_Shutdown /Relay_State main_12V_Out
C19 +12V GND 0.1u
P6 GND +12V 12V_Out
C20 +12V GND 0.1u
P8 GND +5V 5V_Out
C23 +5V GND 0.1u
P9 GND +5V 5V_Out
C24 +5V GND 0.1u
P10 GND +12V /Force_Shutdown /Relay_State main_12V_Out
C21 +12V GND 0.1u
C25 +12V GND 0.1u
U8 Net-_R26-Pad2_ Net-_D15-Pad2_ Net-_C26-Pad2_ GNDPWR Net-_R25-Pad1_ Main_Power Net-_R26-Pad2_ Net-_R26-Pad2_ MC33063A
C26 GNDPWR Net-_C26-Pad2_ 470p
D15 GNDPWR Net-_D15-Pad2_ DIODE
L2 +12P Net-_D15-Pad2_ 22uH
C22 +12P GNDPWR 100u
R27 +12P Net-_R25-Pad1_ 4.7
R25 Net-_R25-Pad1_ GNDPWR 510
C30 GNDPWR Main_Power 22u
R26 Main_Power Net-_R26-Pad2_ 10
U10 Coil_IN To_RelayB NC_61 +BATT CurrentSensor_IN0 RELAY
D20 To_RelayB Coil_IN DIODE
U11 To_RelayB Relay_Out NC_62 +BATT CurrentSensor_IN1 RELAY
D21 Relay_Out To_RelayB DIODE
R35 Net-_IC1-Pad2_ GNDPWR 2.2k
IC2 /PXx Net-_IC2-Pad2_ Net-_IC2-Pad3_ +12P TLP291
R33 /Relay_State GND 10k
R34 Net-_IC2-Pad2_ GND 330
Q3 Relay_Out Net-_Q3-PadG_ GNDPWR MOSFET_N
R39 Net-_Q3-PadG_ Net-_IC2-Pad3_ 10
R36 Net-_IC2-Pad3_ GNDPWR 10k
JP3 GNDPWR Relay_Out Relay_JP
R28 Net-_D16-Pad1_ +BATT 4.7k
D16 Net-_D16-Pad1_ GNDPWR BATT
R29 Net-_D17-Pad1_ Main_Power 4.7k
D17 Net-_D17-Pad1_ GNDPWR Main_POWER
D18 Net-_D18-Pad1_ GNDPWR Relay_BATT
R30 Net-_D18-Pad1_ +12P 2.2k
D19 Net-_D19-Pad1_ GNDPWR Relay_BATT
R31 Net-_D19-Pad1_ Coil_IN 2.2k
C27 Main_Power GNDPWR 470u
U2 Net-_C5-Pad2_ GND /FB +12V +12V Net-_C5-Pad1_ BD9G101G
L1 Net-_C5-Pad1_ Net-_D11-Pad1_ 22u
P18 GNDPWR +BATT BATT_IN
C31 12V_Current_Out GND 470u
D10 GND Net-_C5-Pad1_ DIODE
R14 /FB Net-_D11-Pad1_ 50k
R15 GND /FB 10k
D11 Net-_D11-Pad1_ +5V DIODE
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 0.1u
C6 +12V GND 1u
D12 /PXx /Force_Shutdown DIODE
D13 /PXx /Relay_State DIODE
R37 +BATT Voltage_Divide 1.3k
R38 Voltage_Divide GNDPWR 160
U9 +3.3V GND Net-_R32-Pad2_ 12V_Current_Out +12V ACS781
C33 GND /ADC12_INx 0.1u
R32 /ADC12_INx Net-_R32-Pad2_ R
C32 GND +3.3V 0.1u
.end
