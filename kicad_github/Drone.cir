.title KiCad schematic
R1 Net-_A1-Pad29_ Net-_D1-Pad1_ R_US
D1 Net-_D1-Pad1_ Net-_A1-Pad23_ LED
R2 Net-_D2-Pad1_ Net-_A1-Pad29_ R_US
D2 Net-_D2-Pad1_ Net-_A1-Pad24_ LED
AE1 Net-_AE1-Pad1_ Antenna
U1 NC_01 Net-_A1-Pad26_ Net-_A1-Pad27_ Net-_A1-Pad28_ Net-_A1-Pad25_ NC_02 NC_03 NC_04 Net-_AE1-Pad1_ NC_05 NC_06 NC_07 Net-_A1-Pad4_ NC_08 NC_09 NC_10 RFM95W-868S2
A1 NC_11 NC_12 NC_13 Net-_A1-Pad4_ Net-_A1-Pad5_ NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 Net-_A1-Pad20_ NC_28 Net-_A1-Pad22_ Net-_A1-Pad23_ Net-_A1-Pad24_ Net-_A1-Pad25_ Net-_A1-Pad26_ Net-_A1-Pad27_ Net-_A1-Pad28_ Net-_A1-Pad29_ NC_29 NC_30 NC_31 Arduino_UNO_R3
U3 Net-_A1-Pad22_ Net-_A1-Pad29_ Net-_A1-Pad5_ ADG417BN
U2 Net-_A1-Pad20_ NC_32 NC_33 NC_34 NC_35 Net-_A1-Pad29_ NC_36 Net-_A1-Pad5_ ADG417BN
U4 NC_37 Net-_A2-Pad26_ Net-_A2-Pad27_ Net-_A2-Pad28_ Net-_A2-Pad25_ NC_38 NC_39 NC_40 Net-_AE2-Pad1_ NC_41 NC_42 NC_43 Net-_A2-Pad4_ NC_44 NC_45 NC_46 RFM95W-868S2
AE2 Net-_AE2-Pad1_ Antenna
J1 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 NC_82 NC_83 NC_84 NC_85 NC_86 Raspberry_Pi_2_3
A2 NC_87 NC_88 NC_89 Net-_A2-Pad4_ Net-_A2-Pad5_ NC_90 Net-_A2-Pad7_ NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 Net-_A2-Pad23_ Net-_A2-Pad24_ Net-_A2-Pad25_ Net-_A2-Pad26_ Net-_A2-Pad27_ Net-_A2-Pad28_ NC_106 NC_107 NC_108 NC_109 Arduino_UNO_R3
M1 Net-_A2-Pad23_ Net-_A2-Pad5_ Net-_A2-Pad7_ Motor_Servo
M2 Net-_A2-Pad24_ Net-_A2-Pad5_ Net-_A2-Pad7_ Motor_Servo
.end
