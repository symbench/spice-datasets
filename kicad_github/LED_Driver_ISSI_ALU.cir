.title KiCad schematic
U1 Net-_D1-Pad2_ GND Net-_R8-Pad1_ Net-_C3-Pad1_ VCC IS31LT3360
L1 Net-_D1-Pad2_ Net-_C3-Pad2_ 47uH
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 1uF
C2 VCC GND 0.1uF
R1 Net-_C3-Pad1_ VCC 0.22
D3 Net-_D3-Pad1_ Net-_C3-Pad1_ LED
D4 Net-_D4-Pad1_ Net-_D3-Pad1_ LED
D5 Net-_D5-Pad1_ Net-_D4-Pad1_ LED
D6 Net-_D6-Pad1_ Net-_D5-Pad1_ LED
D7 Net-_D7-Pad1_ Net-_D6-Pad1_ LED
D8 Net-_D8-Pad1_ Net-_D7-Pad1_ LED
D9 Net-_D10-Pad2_ Net-_D8-Pad1_ LED
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ LED
D11 Net-_D11-Pad1_ Net-_D10-Pad1_ LED
D12 Net-_C3-Pad2_ Net-_D11-Pad1_ LED
C1 VCC GND 100uF
TH1 /NTC /3.3V Thermistor_NTC
J1 NC_01 /ADJ_LED GND VCC /NTC NC_02 /12V_Fan /3.3V NC_03 NC_04 5055780871
J2 /12V_Fan GND NC_05 NC_06 505578-0271
R8 Net-_R8-Pad1_ /ADJ_LED 100
R15 VCC VCC 0
D1 VCC Net-_D1-Pad2_ PMEG4010EGWX
U2 Net-_D2-Pad2_ GND Net-_R10-Pad1_ Net-_C6-Pad1_ VCC IS31LT3360
L2 Net-_D2-Pad2_ Net-_C6-Pad2_ 47uH
C6 Net-_C6-Pad1_ Net-_C6-Pad2_ 1uF
C5 VCC GND 0.1uF
R3 Net-_C6-Pad1_ VCC 0.22
D13 Net-_D13-Pad1_ Net-_C6-Pad1_ LED
D14 Net-_D14-Pad1_ Net-_D13-Pad1_ LED
D15 Net-_D15-Pad1_ Net-_D14-Pad1_ LED
D16 Net-_D16-Pad1_ Net-_D15-Pad1_ LED
D17 Net-_D17-Pad1_ Net-_D16-Pad1_ LED
D18 Net-_D18-Pad1_ Net-_D17-Pad1_ LED
D19 Net-_D19-Pad1_ Net-_D18-Pad1_ LED
D20 Net-_D20-Pad1_ Net-_D19-Pad1_ LED
D21 Net-_D21-Pad1_ Net-_D20-Pad1_ LED
D22 Net-_C6-Pad2_ Net-_D21-Pad1_ LED
C4 VCC GND 100uF
D2 VCC Net-_D2-Pad2_ PMEG4010EGWX
R10 Net-_R10-Pad1_ /ADJ_LED 100
U3 Net-_D23-Pad2_ GND Net-_R11-Pad1_ Net-_C9-Pad1_ VCC IS31LT3360
L3 Net-_D23-Pad2_ Net-_C9-Pad2_ 47uH
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 1uF
C8 VCC GND 0.1uF
R4 Net-_C9-Pad1_ VCC 0.22
D24 Net-_D24-Pad1_ Net-_C9-Pad1_ LED
D25 Net-_D25-Pad1_ Net-_D24-Pad1_ LED
D26 Net-_D26-Pad1_ Net-_D25-Pad1_ LED
D27 Net-_D27-Pad1_ Net-_D26-Pad1_ LED
D28 Net-_D28-Pad1_ Net-_D27-Pad1_ LED
D29 Net-_D29-Pad1_ Net-_D28-Pad1_ LED
D30 Net-_D30-Pad1_ Net-_D29-Pad1_ LED
D31 Net-_D31-Pad1_ Net-_D30-Pad1_ LED
D32 Net-_D32-Pad1_ Net-_D31-Pad1_ LED
D33 Net-_C9-Pad2_ Net-_D32-Pad1_ LED
C7 VCC GND 100uF
D23 VCC Net-_D23-Pad2_ PMEG4010EGWX
R11 Net-_R11-Pad1_ /ADJ_LED 100
U4 Net-_D34-Pad2_ GND Net-_R12-Pad1_ Net-_C12-Pad1_ VCC IS31LT3360
L4 Net-_D34-Pad2_ Net-_C12-Pad2_ 47uH
C12 Net-_C12-Pad1_ Net-_C12-Pad2_ 1uF
C11 VCC GND 0.1uF
R5 Net-_C12-Pad1_ VCC 0.22
D35 Net-_D35-Pad1_ Net-_C12-Pad1_ LED
D36 Net-_D36-Pad1_ Net-_D35-Pad1_ LED
D37 Net-_D37-Pad1_ Net-_D36-Pad1_ LED
D38 Net-_D38-Pad1_ Net-_D37-Pad1_ LED
D39 Net-_D39-Pad1_ Net-_D38-Pad1_ LED
D40 Net-_D40-Pad1_ Net-_D39-Pad1_ LED
D41 Net-_D41-Pad1_ Net-_D40-Pad1_ LED
D42 Net-_D42-Pad1_ Net-_D41-Pad1_ LED
D43 Net-_D43-Pad1_ Net-_D42-Pad1_ LED
D44 Net-_C12-Pad2_ Net-_D43-Pad1_ LED
C10 VCC GND 100uF
D34 VCC Net-_D34-Pad2_ PMEG4010EGWX
R12 Net-_R12-Pad1_ /ADJ_LED 100
U5 Net-_D45-Pad2_ GND Net-_R13-Pad1_ Net-_C15-Pad1_ VCC IS31LT3360
L5 Net-_D45-Pad2_ Net-_C15-Pad2_ 47uH
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 1uF
C14 VCC GND 0.1uF
R6 Net-_C15-Pad1_ VCC 0.22
D46 Net-_D46-Pad1_ Net-_C15-Pad1_ LED
D47 Net-_D47-Pad1_ Net-_D46-Pad1_ LED
D48 Net-_D48-Pad1_ Net-_D47-Pad1_ LED
D49 Net-_D49-Pad1_ Net-_D48-Pad1_ LED
D50 Net-_D50-Pad1_ Net-_D49-Pad1_ LED
D51 Net-_D51-Pad1_ Net-_D50-Pad1_ LED
D52 Net-_D52-Pad1_ Net-_D51-Pad1_ LED
D53 Net-_D53-Pad1_ Net-_D52-Pad1_ LED
D54 Net-_D54-Pad1_ Net-_D53-Pad1_ LED
D55 Net-_C15-Pad2_ Net-_D54-Pad1_ LED
C13 VCC GND 100uF
D45 VCC Net-_D45-Pad2_ PMEG4010EGWX
R13 Net-_R13-Pad1_ /ADJ_LED 100
U6 Net-_D56-Pad2_ GND Net-_R14-Pad1_ Net-_C18-Pad1_ VCC IS31LT3360
L6 Net-_D56-Pad2_ Net-_C18-Pad2_ 47uH
C18 Net-_C18-Pad1_ Net-_C18-Pad2_ 1uF
C17 VCC GND 0.1uF
R7 Net-_C18-Pad1_ VCC 0.22
D57 Net-_D57-Pad1_ Net-_C18-Pad1_ LED
D58 Net-_D58-Pad1_ Net-_D57-Pad1_ LED
D59 Net-_D59-Pad1_ Net-_D58-Pad1_ LED
D60 Net-_D60-Pad1_ Net-_D59-Pad1_ LED
D61 Net-_D61-Pad1_ Net-_D60-Pad1_ LED
D62 Net-_D62-Pad1_ Net-_D61-Pad1_ LED
D63 Net-_D63-Pad1_ Net-_D62-Pad1_ LED
D64 Net-_D64-Pad1_ Net-_D63-Pad1_ LED
D65 Net-_D65-Pad1_ Net-_D64-Pad1_ LED
D66 Net-_C18-Pad2_ Net-_D65-Pad1_ LED
C16 VCC GND 100uF
D56 VCC Net-_D56-Pad2_ PMEG4010EGWX
R14 Net-_R14-Pad1_ /ADJ_LED 100
.end
