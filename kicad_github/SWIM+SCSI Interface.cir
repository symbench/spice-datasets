.title KiCad schematic
J5 Net-_J5-Pad1_ /DB0 Net-_J5-Pad1_ /DB1 Net-_J5-Pad1_ /DB2 Net-_J5-Pad1_ /DB3 Net-_J5-Pad1_ /DB4 Net-_J5-Pad1_ /DB5 Net-_J5-Pad1_ /DB6 Net-_J5-Pad1_ /DB7 Net-_J5-Pad1_ /DBP Net-_J5-Pad1_ NC_01 Net-_J5-Pad1_ NC_02 Net-_J5-Pad1_ NC_03 Net-_J5-Pad1_ NC_04 Net-_J5-Pad1_ NC_05 Net-_J5-Pad1_ NC_06 Net-_J5-Pad1_ /ATN* Net-_J5-Pad1_ NC_07 Net-_J5-Pad1_ /BSY* Net-_J5-Pad1_ /ACKS* Net-_J5-Pad1_ /RST* Net-_J5-Pad1_ /MSG* Net-_J5-Pad1_ /SEL* Net-_J5-Pad1_ /C-D* Net-_J5-Pad1_ /I-O* Net-_J5-Pad1_ /I-O* SCSI
J6 Net-_J6-Pad1_ Net-_J6-Pad1_ Net-_J6-Pad1_ Net-_J6-Pad1_ NC_08 /+5V-DSK NC_09 NC_10 NC_11 /+5V-DSK /FPH0.F /FPH1.F /FPH2.F /FPH3.F /WRREQ.F /HDSEL.F /ENABL2*.F /RDDATA.F NC_12 Net-_J6-Pad1_ Net-_J6-Pad1_ DB-19
UJ1 Net-_UJ1-Pad1_ NC_13 /WRREQ /D_24_ /D_25_ /D_26_ /D_27_ NC_14 +5VSWIM Net-_UJ1-Pad1_ /D_28_ /D_29_ /D_30_ NC_15 /D_31_ /ENABL2* /ENABL1* /RDDATA +5VSWIM Net-_UJ1-Pad1_ /RDDATA RESET* NC_16 NC_17 +5VSWIM /FPH3 /FPH1 NC_18 Net-_UJ1-Pad1_ /FPH0 /FPH2 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 +5VSWIM SWIM
RP10 Net-_RP10-Pad1_ /RDDATA.F /ENABL2*.F /HDSEL.F /WRREQ.F /FPH3.F /FPH2.F /FPH1.F /FPH0.F Net-_RP10-Pad1_ Net-_RP10-Pad11_ /FPH0 /FPH1 /FPH2 /FPH3 /WRREQ HDSEL /ENABL2* /RDDATA Net-_RP10-Pad11_ RCNET
J1 Net-_J1-Pad1_ /FPH0 Net-_J1-Pad1_ /FPH1 Net-_J1-Pad1_ /FPH2 Net-_J1-Pad1_ /FPH3 NC_25 /WRREQ NC_26 HDSEL Net-_J1-Pad13_ /ENABL1* Net-_J1-Pad13_ /RDDATA Net-_J1-Pad13_ NC_27 Net-_J1-Pad13_ NC_28 Ribbon Connector
UI1 /DB7 /RST* Net-_UI1-Pad3_ /BSY* /SEL* /ATN* RESET* NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 /D_31_ /D_30_ /D_29_ NC_41 /D_28_ /D_27_ /D_26_ /D_25_ /D_24_ /MSG* /C-D* Net-_UI1-Pad3_ /I-O* /ACKS* /I-O* /DBP NC_42 /DB0 /DB1 /DB2 /DB3 /DB4 NC_43 /DB5 /DB6 53C80
.end
