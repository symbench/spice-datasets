.title KiCad schematic
SW0 GND /KEY0 K0
SW1 /KEY1 GND K0
SW2 /KEY2 GND K0
SW3 /KEY3 GND K0
SW4 /KEY4 GND K0
SW5 /KEY5 GND K0
SW6 /KEY6 GND K0
SW7 /KEY7 GND K0
SW8 /KEY8 GND K0
SW9 /KEY9 GND K0
SW20 /KEY20 GND K0
SW21 /KEY21 GND K0
SW22 /KEY22 GND K0
SW23 /KEY23 GND K0
SW24 /KEY24 GND K0
SW25 /KEY25 GND K0
SW26 /KEY26 GND K0
SW27 /KEY27 GND K0
SW28 /KEY28 GND K0
SW29 /KEY29 GND K0
SW40 /KEY40 GND K0
SW41 /KEY41 GND K0
SW42 /KEY42 GND K0
SW43 /KEY43 GND K0
SW44 /KEY44 GND K0
SW45 /KEY45 GND K0
SW46 /KEY46 GND K0
SW47 /KEY47 GND K0
SW48 /KEY48 GND K0
SW49 /KEY49 GND K0
SW60 /KEY60 GND K0
SW61 /KEY61 GND K0
SW62 /KEY62 GND K0
SW63 /KEY63 GND K0
SW64 /KEY64 GND K0
SW65 /KEY65 GND K0
SW66 /KEY66 GND K0
SW67 /KEY67 GND K0
SW68 GND /KEY68 K0
SW69 /KEY69 GND K0
SW10 /KEY10 GND K0
SW11 /KEY11 GND K0
SW12 /KEY12 GND K0
SW13 /KEY13 GND K0
SW14 /KEY14 GND K0
SW15 /KEY14.5 GND K0
SW16 /KEY16 GND K0
SW17 /KEY16 GND K0
SW18 NC_01 GND K0
SW19 GND /KEY19 K0
SW30 /KEY30 GND K0
SW31 /KEY31 GND K0
SW32 /KEY32 GND K0
SW33 /KEY33 GND K0
SW34 /KEY34 GND K0
SW35 /KEY35 GND K0
SW36 GND /KEY36 K0
SW37 /KEY37 GND K0
SW38 GND /KEY38 K0
SW39 /KEY39 GND K0
SW50 /KEY50 GND K0
SW51 /KEY51 GND K0
SW52 GND /KEY52 K0
SW53 /KEY53 GND K0
SW54 /KEY54 GND K0
SW55 /KEY55 GND K0
SW56 /KEY56 GND K0
SW57 /KEY57 GND K0
SW58 /KEY58 GND K0
SW59 /KEY59 GND K0
SW70 /KEY70 GND K0
SW71 NC_02 GND K0
SW72 /KEY72 GND K0
SW73 NC_03 GND K0
U1 /KEY53 /KEY69 GND VCC /KEY68 /KEY52 /KEY36 /KEY19 /KEY0 /KEY1 /KEY20 /KEY37 GND VCC /KEY2 /KEY3 /KEY4 /KEY5 /KEY6 /KEY7 /KEY8 /KEY9 GND VCC /KEY10 /KEY11 /KEY12 /KEY13 /KEY14 /KEY14.5 Net-_J1-PadA7_ Net-_J1-PadA6_ GND VCC /KEY16 /KEY54 /KEY21 /KEY22 /KEY23 /KEY24 /KEY25 /KEY26 GND VCC /KEY82 /KEY81 /KEY27 /KEY28 /KEY29 /KEY30 /KEY31 /KEY32 GND VCC /KEY33 /KEY34 /KEY35 /KEY38 /KEY39 /KEY40 /KEY41 /KEY42 GND VCC /KEY43 /KEY44 /KEY45 /KEY46 /KEY47 /KEY48 /KEY49 /KEY50 GND VCC /KEY51 /KEY55 /KEY56 /KEY57 /KEY58 /KEY59 /KEY60 /KEY61 VCC GND /KEY62 /KEY63 /KEY64 /KEY65 /PDI /RST /KEY66 /KEY67 GND VCC /KEY70 /KEY72 /KEY74 /KEY78 /KEY79 /KEY80 ATXMEGA128A1U-AU
J1 GND +5V Net-_J1-PadA5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_04 +5V GND GND +5V Net-_J1-PadB5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_05 +5V GND NC_06 USB_Type_C_2.0_Receptacle
R1 Net-_J1-PadB5_ GND 5.1k
P1 /PDI VCC NC_07 NC_08 /RST GND TC2030-IDC
U2 +5V GND +5V NC_09 VCC MIC550X
C1 VCC GND 10uf
R2 Net-_J1-PadA5_ GND 5.1k
SW74 /KEY74 GND K0
SW75 NC_10 GND K0
SW76 NC_11 GND K0
SW77 NC_12 GND K0
SW78 /KEY78 GND K0
SW79 /KEY79 GND K0
SW80 /KEY80 GND K0
SW81 /KEY81 GND K0
SW82 /KEY82 GND K0
C2 GND VCC 10uf
SW14.5 /KEY14.5 GND K0
.end
