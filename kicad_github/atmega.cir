.title KiCad schematic
J1.2 GND /PDI /PDO PB1 /RESET 5V Conn_01x06
R1.2 Net-_D101-Pad2_ PB5 R
D101 GND Net-_D101-Pad2_ LED
R1.1 5V /RESET R
X101 Net-_C102-Pad1_ Net-_C103-Pad1_ Crystal
C103 Net-_C103-Pad1_ GND C
C102 Net-_C102-Pad1_ GND C
R1.3 /TX /PDI R
J1.1 5V /PDO /TX GND Conn_01x04
SW1 GND /RESET SW_Push
J1.3 PG0 PG1 PC0 PC1 B_STAT PC3 PC4 PC5 M4A M4B M3A M3B M2A M2B M1A M1B Conn_01x16
RV1 5V PF2 GND R_POT
RV2 5V PF1 GND R_POT
RV3 5V PF0 GND R_POT
C101 Net-_C101-Pad1_ GND C
J1.4 PA2 PA1 PA0 PF7 PF6 PF5 PF4 PF3 PF2 PF1 PF0 Conn_01x11
J1.5 PE2 M1PWM M2PWM M3PWM PE6 PE7 PB0 PB1 PB2 PB3 M4PWM PB5 PB6 Conn_01x13
U101 NC_01 /TX /PDO PE2 M1PWM M2PWM M3PWM PE6 PE7 PB0 PB1 PB2 PB3 M4PWM PB5 PB6 PB7 PG3 PG4 /RESET 5V GND Net-_C103-Pad1_ Net-_C102-Pad1_ PD0 PD1 B_TXD B_RXD PD4 PD5 PD6 PD7 PG0 PG1 PC0 PC1 B_STAT PC3 PC4 PC5 M4A M4B M3A M3B M2A M2B M1A M1B PA2 PA1 PA0 5V GND PF7 PF6 PF5 PF4 PF3 PF2 PF1 PF0 Net-_C101-Pad1_ GND 5V ATmega128A-AU
J1.6 PB7 PG3 PG4 PD0 PD1 B_TXD B_RXD PD4 PD5 PD6 PD7 Conn_01x11
C104 GND 5V C
C105 GND 5V C
J1.7 GND 5V PD0 PD1 Conn_01x04
J1.11 NC_02 EN
J1.12 NC_03 ALED
J1.13 NC_04 STAT
J1.14 NC_05 SELECT
J1.15 NC_06
J1.16 NC_07
J1.17 NC_08
J1.22 NC_09
J1.21 NC_10
J1.20 NC_11
J1.19 NC_12
J1.18 NC_13
J1.23 NC_14 GND
J1.24 NC_15 VCC
J1.25 NC_16 RST
J1.26 NC_17
J1.27 NC_18 SWI
J1.28 NC_19
J1.29 NC_20
J1.34 NC_21 RXD
J1.33 NC_22 CTS
J1.32 NC_23 RTS
J1.31 NC_24
J1.30 NC_25
J1.35 NC_26 TXD
R1.4 Net-_D1.2-Pad2_ Net-_J1.36-Pad4_ R
D1.2 GND Net-_D1.2-Pad2_ LED
R1.5 Net-_D1.3-Pad2_ Net-_J1.36-Pad3_ R
D1.3 GND Net-_D1.3-Pad2_ LED
R1.6 Net-_D1.4-Pad2_ Net-_J1.36-Pad2_ R
D1.4 GND Net-_D1.4-Pad2_ LED
R1.7 Net-_D1.5-Pad2_ Net-_J1.36-Pad1_ R
D1.5 GND Net-_D1.5-Pad2_ LED
J1.36 Net-_J1.36-Pad1_ Net-_J1.36-Pad2_ Net-_J1.36-Pad3_ Net-_J1.36-Pad4_ Conn_01x04
JP1.1 Net-_J1.36-Pad4_ PB3 M4PWM
JP1.2 Net-_J1.36-Pad3_ PB2 M4PWM
JP1.3 Net-_J1.36-Pad2_ PB0 M4PWM
JP1.4 Net-_J1.36-Pad1_ PE7 M4PWM
J37 GND 3.3V Net-_J37-Pad3_ B_TXD B_STAT Conn_01x05
Q1 Net-_Q1-Pad1_ 3.3V 5V AO3400A
R1.8 Net-_Q1-Pad1_ 5V R
R1.9 GND Net-_Q1-Pad1_ R
R1.12 GND 3.3V R
R1.10 Net-_J37-Pad3_ B_RXD R
R1.11 GND Net-_J37-Pad3_ R
SW1.2 PG3 GND SW_Push
SW1.3 PG4 GND SW_Push
R1.13 PG3 5V R
R1.14 PG4 5V R
.end
