.title KiCad schematic
U1 NC_01 RXD0 TXD0 NC_02 NC_03 D4 NC_04 NC_05 NC_06 +5V GND RXD2 TXD2 NC_07 NC_08 NC_09 NC_10 NC_11 SS SCK MOSI MISO NC_12 NC_13 NC_14 Net-_R4-Pad2_ NC_15 NC_16 NC_17 RESET +5V GND Net-_C1-Pad1_ Net-_C2-Pad1_ NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 RXD1 TXD1 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 +5V GND RXD3 TXD3 D54 D55 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 +5V GND NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 +5V GND Net-_C9-Pad1_ NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 ATMEGA2560-16AUR
Y1 Net-_C1-Pad1_ Net-_C2-Pad1_ Crystal
C1 Net-_C1-Pad1_ GND C
C2 Net-_C2-Pad1_ GND C
R4 Net-_D1-Pad2_ Net-_R4-Pad2_ R
D1 GND Net-_D1-Pad2_ LED
R5 +5V RESET R
C3 +5V GND C
C4 +5V GND C
C5 +5V GND C
C7 +5V GND C
C8 +5V GND C
C9 Net-_C9-Pad1_ GND C
C10 RESET GND C
D2 Net-_C9-Pad1_ GND LM4040DBZ-3
R6 +5V Net-_C9-Pad1_ R
J1 MISO +5V SCK MOSI RESET GND AVR-ISP-6
J2 DTR TXD0 RXD0 +5V GND GND FTDI_Header
C6 RESET DTR C
R1 SCK rSCK R
R2 MOSI rMOSI R
R3 MISO rMISO R
U2 NC_71 NC_72 NC_73 +5V GND NC_74 Net-_C14-Pad1_ Net-_C13-Pad1_ NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 SpdMOSI SpdMISO SpdSCK +5V NC_81 Net-_C11-Pad1_ GND NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 SpdRESET SpdRXD SpdTXD NC_89 ATmega328PB-AU
Y2 Net-_C13-Pad1_ Net-_C14-Pad1_ Crystal
C13 Net-_C13-Pad1_ GND C
C14 Net-_C14-Pad1_ GND C
C15 +5V GND C
C11 Net-_C11-Pad1_ GND C
D3 Net-_C11-Pad1_ GND LM4040DBZ-3
R7 +5V Net-_C11-Pad1_ R
R8 +5V SpdRESET R
C12 SpdRESET GND C
J3 SpdMISO +5V SpdSCK SpdMOSI SpdRESET GND AVR-ISP-6
J4 SpdDTR SpdTXD SpdRXD +5V GND GND FTDI_Header
C16 SpdRESET SpdDTR C
U9 RXD1 DIR1 DIR1 TXD1 GND NC_90 NC_91 +5V MAX485E
C30 +5V GND C
U10 RXD2 DIR2 DIR2 TXD2 GND NC_92 NC_93 +5V MAX485E
C31 +5V GND C
U11 RXD3 DIR3 DIR3 TXD3 GND 485A3 485B3 +5V MAX485E
C32 +5V GND C
R28 Net-_D6-Pad2_ +5V R
D6 RXD1 Net-_D6-Pad2_ LED
R29 Net-_D7-Pad2_ +5V R
D7 TXD1 Net-_D7-Pad2_ LED
R30 Net-_D8-Pad2_ +5V R
D8 RXD2 Net-_D8-Pad2_ LED
R31 Net-_D9-Pad2_ +5V R
D9 TXD2 Net-_D9-Pad2_ LED
R32 Net-_D10-Pad2_ +5V R
D10 RXD3 Net-_D10-Pad2_ LED
R33 Net-_D11-Pad2_ +5V R
D11 TXD3 Net-_D11-Pad2_ LED
U12 SpdRXD xxxxxxxxxx xxxxxxxxxx SpdTXD GND 485A3 485B3 +5V MAX485E
C33 +5V GND C
R34 Net-_D12-Pad2_ +5V R
D12 SpdRXD Net-_D12-Pad2_ LED
R35 Net-_D13-Pad2_ +5V R
D13 SpdTXD Net-_D13-Pad2_ LED
U3 +5V NC_94 NC_95 NC_96 GND NC_97 NC_98 Net-_C25-Pad1_ Net-_C21-Pad1_ GND NC_99 NC_100 D4 rSCK rMOSI rMISO SS Net-_C18-Pad1_ +5V Net-_U3-Pad20_ Net-_U3-Pad21_ NC_101 NC_102 Net-_U3-Pad20_ NC_103 GND +5V Net-_U3-Pad21_ MCP25625-x-SS
C18 Net-_C18-Pad1_ GND C
C17 +5V GND C
R9 Net-_C18-Pad1_ +5V R
C21 Net-_C21-Pad1_ GND C
C25 Net-_C25-Pad1_ GND C
Y3 Net-_C21-Pad1_ Net-_C25-Pad1_ Crystal
J5 Net-_J5-Pad1_ Net-_C19-Pad1_ Net-_C20-Pad1_ Net-_C19-Pad2_ Net-_J5-Pad5_ USB_B
U4 Net-_U4-Pad1_ Net-_U4-Pad2_ Net-_C24-Pad1_ Net-_U4-Pad4_ Net-_C19-Pad2_ NC_104 Net-_D5-Pad1_ Net-_R12-Pad2_ Net-_R11-Pad2_ Net-_C24-Pad1_ Net-_C24-Pad1_ +5V Net-_C19-Pad2_ Net-_D4-Pad1_ Net-_J6-Pad1_ Net-_R13-Pad2_ FT230XS
R15 Net-_D4-Pad2_ Net-_C24-Pad1_ R
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R16 Net-_D5-Pad2_ Net-_C24-Pad1_ R
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ LED
R13 Net-_J5-Pad1_ Net-_R13-Pad2_ R
R14 Net-_R13-Pad2_ Net-_C19-Pad2_ R
R12 Net-_C20-Pad1_ Net-_R12-Pad2_ R
R11 Net-_C19-Pad1_ Net-_R11-Pad2_ R
C24 Net-_C24-Pad1_ Net-_C19-Pad2_ C
C20 Net-_C20-Pad1_ Net-_C19-Pad2_ C
C19 Net-_C19-Pad1_ Net-_C19-Pad2_ C
C23 +5V Net-_C19-Pad2_ C
C22 +5V Net-_C19-Pad2_ CP
R10 Net-_C19-Pad2_ Net-_J5-Pad5_ R
U5 Net-_J6-Pad1_ +5V GND SpdRXD Net-_U4-Pad1_ RXD0 ADG779
C27 GND +5V C
R17 +5V Net-_J6-Pad1_ R
U6 Net-_J6-Pad1_ +5V GND SpdTXD Net-_U4-Pad4_ TXD0 ADG779
C28 GND +5V C
U7 Net-_J6-Pad1_ +5V GND SpdDTR Net-_U4-Pad2_ DTR ADG779
C29 GND +5V C
J6 Net-_J6-Pad1_ Net-_C19-Pad2_ Conn_01x02
J7 NC_105 3V3ssSD 3V3MOSI +3V3 3V3SCK GND 3V3MISO NC_106 NC_107 Micro_SD_Card
Q3 3V3MISO rMISO 3V3MISO Q_NMOS_GDS
Q2 3V3SCK rSCK 3V3SCK Q_NMOS_GDS
Q1 3V3MOSI rMOSI 3V3MOSI Q_NMOS_GDS
R20 rMISO +5V R
R19 rSCK +5V R
R18 rMOSI +5V R
R23 +3V3 3V3MOSI R
R24 +3V3 3V3SCK R
R25 +3V3 3V3MISO R
Q4 3V3ssSD D54 3V3ssSD Q_NMOS_GDS
R21 D54 +5V R
R26 +3V3 3V3ssSD R
Q5 3V3ssFlash D55 3V3ssFlash Q_NMOS_GDS
R22 D55 +5V R
R27 +3V3 3V3ssFlash R
C26 +3V3 GND C
U8 NC_108 NC_109 NC_110 NC_111 NC_112 NC_113 NC_114 NC_115 M25PX32-VMW
Q6 Net-_D14-Pad2_ NC_116 +24V Q_PMOS_GDS
D14 +24V Net-_D14-Pad2_ D_Zener
R36 Net-_D14-Pad2_ GND R
U13 Net-_C36-Pad2_ Net-_R37-Pad2_ Net-_R40-Pad2_ Net-_C34-Pad2_ Net-_Q7-Pad3_ Net-_Q7-Pad1_ Net-_C35-Pad2_ +24V Net-_C34-Pad2_ LM25085MY
R37 +24V Net-_R37-Pad2_ R
C34 +24V Net-_C34-Pad2_ CP
C35 +24V Net-_C35-Pad2_ C
C36 +24V Net-_C36-Pad2_ C
R39 +24V Net-_Q7-Pad3_ R
R38 +24V Net-_C36-Pad2_ R
D15 Net-_D15-Pad1_ Net-_C34-Pad2_ D_Schottky
Q7 Net-_Q7-Pad1_ Net-_D15-Pad1_ Net-_Q7-Pad3_ Q_PMOS_GDS
L1 Net-_D15-Pad1_ +12V L
C37 +12V Net-_C34-Pad2_ C
R40 +12V Net-_R40-Pad2_ R
R41 Net-_R40-Pad2_ Net-_C34-Pad2_ R
C38 +12V Net-_C34-Pad2_ CP
.end
