.title KiCad schematic
J1 /Sheet5DD758E7/+5V /Sheet5DD758E7/+5V GND GND NC_01 /Sheet5DD758E7/LD_GPS NC_02 /Sheet5DD758E7/SHDN_GPS NC_03 /Sheet5DD758E7/D0_GPS NC_04 /Sheet5DD758E7/D1_GPS NC_05 /Sheet5DD758E7/D2_GPS NC_06 /Sheet5DD758E7/D3_GPS /Sheet5DD758E7/TXE#_USB NC_07 NC_08 /Sheet5DD758E7/WR#_GPS /Sheet5DD758E7/SCLK_USB /Sheet5DD758E7/SCLK_GPS /Sheet5DD758E7/SDI_USB NC_09 /Sheet5DD758E7/SDO_USB /Sheet5DD758E7/SDO_GPS /Sheet5DD758E7/SCS_USB /Sheet5DD758E7/SCS_GPS Conn_02x14_Odd_Even
J3 /Sheet5DD758E7/SCS_USB /Sheet5DD758E7/SDO_USB /Sheet5DD758E7/SDI_USB /Sheet5DD758E7/SCLK_USB Net-_J2-Pad12_ NC_10 /Sheet5DD758E7/WR#_GPS /Sheet5DD758E7/TXE#_USB Net-_J2-Pad9_ Net-_J2-Pad8_ NC_11 /Sheet5DD758E7/D3_GPS /Sheet5DD758E7/D2_GPS /Sheet5DD758E7/D1_GPS /Sheet5DD758E7/D0_GPS /Sheet5DD758E7/SHDN_GPS /Sheet5DD758E7/LD_GPS NC_12 GND /Sheet5DD758E7/+5V Conn_01x20
J4 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 GND NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 Conn_01x20
J6 NC_32 NC_33 NC_34 NC_35 NC_36 GND NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 Net-_J6-Pad16_ Net-_J6-Pad17_ Net-_J6-Pad18_ Net-_J6-Pad19_ Net-_J6-Pad20_ Conn_01x20
J7 Net-_J7-Pad1_ GND Net-_J6-Pad18_ NC_46 Net-_J6-Pad20_ Net-_J6-Pad16_ Net-_J6-Pad19_ Net-_J6-Pad17_ Net-_J5-Pad1_ GND Microsemi_FlashPro-JTAG-10
J5 Net-_J5-Pad1_ Net-_J5-Pad2_ NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 GND NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 Conn_01x20
J2 GND /Sheet5DD758E7/LD_GPS /Sheet5DD758E7/SHDN_GPS /Sheet5DD758E7/D0_GPS /Sheet5DD758E7/D1_GPS /Sheet5DD758E7/D2_GPS /Sheet5DD758E7/D3_GPS Net-_J2-Pad8_ Net-_J2-Pad9_ /Sheet5DD758E7/TXE#_USB /Sheet5DD758E7/WR#_GPS Net-_J2-Pad12_ /Sheet5DD758E7/SCLK_USB /Sheet5DD758E7/SDI_USB /Sheet5DD758E7/SDO_USB /Sheet5DD758E7/SCS_USB Conn_01x16
TP3 /Sheet5DD758E7/SDO_GPS wire jumper
TP6 Net-_J2-Pad9_ wire jumper
TP2 /Sheet5DD758E7/SCS_GPS wire jumper
TP5 Net-_J2-Pad12_ wire jumper
TP1 /Sheet5DD758E7/SCLK_GPS wire jumper
TP4 Net-_J2-Pad8_ wire jumper
TP7 Net-_J5-Pad2_ wire jumper
TP8 Net-_J7-Pad1_ wire jumper
.end
