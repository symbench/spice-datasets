.title KiCad schematic
U2 GND GND CC_SCL0 CC_SDA0 NC_01 NC_02 CC_UART1_TX CC_UART1_RX NC_03 NC_04 NC_05 JTAG_TDI FLASH_DIN FLASH_CS FLASH_CLK GND FLASH_DOUT JTAG_TDO NC_06 NC_07 JTAG_TCK JTAG_TMS SOP2 SOP1 NC_08 NC_09 GND GND NC_10 GND Net-_U1-Pad1_ GND NC_11 SOP0 CC_nRESET Net-_R8-Pad1_ +3V3 GND Net-_R9-Pad1_ +3V3 NC_12 NC_13 GND STATUS_LED_1 NC_14 CC_UART0_TX CC_UART0_RX STATUS_LED_2 CC_ADC_CH2 CC_ADC_CH3 NC_15 CC_GPIO7 CC_GPIO8 NC_16 GND GND GND GND GND GND GND GND GND CC3220MODSFMOB
U1 Net-_U1-Pad1_ GND Net-_J4-Pad1_ GND DEA202450BT-1294C1-H
J4 Net-_J4-Pad1_ GND WIFI SMA
R4 SOP0 GND 100k
R5 SOP1 GND 100k
R7 SOP2 GND 100k
R3 JTAG_TCK GND 100k
R6 +3V3 CC_nRESET 10k
C3 CC_nRESET GND 0.1uF
R8 Net-_R8-Pad1_ +3V3 DNP
C1 +3V3 GND 100uF
C2 +3V3 GND 100uF
C4 +3V3 GND 0.1uF
C5 +3V3 GND 0.1uF
C6 +3V3 GND 0.1uF
R9 Net-_R9-Pad1_ +3V3 DNP
R2 Net-_Q2-Pad3_ Net-_D6-Pad1_ 270
D6 Net-_D6-Pad1_ +3V3 LED
Q2 STATUS_LED_1 GND Net-_Q2-Pad3_ BSS138
R13 GND STATUS_LED_1 100k
R1 Net-_Q1-Pad3_ Net-_D5-Pad1_ 270
D5 Net-_D5-Pad1_ +3V3 LED
Q1 STATUS_LED_2 GND Net-_Q1-Pad3_ BSS138
R10 GND STATUS_LED_2 100k
U4 +3V3 CC_SCL0 +3V3 CC_SDA0 Net-_R16-Pad2_ Net-_R16-Pad2_ Net-_R14-Pad2_ Net-_R14-Pad2_ NC_17 NC_18 NC_19 NC_20 NC_21 GND GND GND GND GND GND GND Net-_C29-Pad1_ +3V3 +3V3 Net-_C30-Pad1_ LSM9DS1
C30 Net-_C30-Pad1_ GND 0.1uF
C29 Net-_C29-Pad1_ GND 0.01uF
R14 +3V3 Net-_R14-Pad2_ 10k
R16 +3V3 Net-_R16-Pad2_ 10k
C34 +3V3 GND 10uF
C33 +3V3 GND 0.1uF
C31 +3V3 GND 0.1uF
C36 +3V3 GND 0.1uF
C35 +3V3 GND 4.7uF
R19 Net-_R19-Pad1_ +3V3 100K
R11 +3V3 CC_SCL0 4.7k
R12 +3V3 CC_SDA0 4.7k
U6 GND Net-_R19-Pad1_ CC_SDA0 CC_SCL0 GND +3V3 GND +3V3 BMP280
U8 /Page3/XBEE_VCC /Page3/TX_ISOLATED /Page3/RX_ISOLATED NC_22 XBEE_RESET Net-_R21-Pad1_ NC_23 XBEE_DTR GND NC_24 XBEE_CTS NC_25 GND Net-_TP2-Pad1_ XBEE_RTS NC_26 NC_27 NC_28 NC_29 XBP9B-DPST-001
C41 /Page3/XBEE_VCC GND 10uF
C40 /Page3/XBEE_VCC GND 0.01uF
U10 +3V3 GND CC_GPIO7 Net-_C44-Pad1_ Net-_R23-Pad2_ /Page3/XBEE_VCC TPS22918
R23 /Page3/XBEE_VCC Net-_R23-Pad2_ 0
C44 Net-_C44-Pad1_ GND 0.001uF
R24 CC_GPIO7 GND 100K
C46 GND +3V3 1uF
C42 /Page3/XBEE_VCC GND 22uF
TP2 Net-_TP2-Pad1_ Test_Point
R21 Net-_R21-Pad1_ Net-_D1-Pad2_ 330
D1 GND Net-_D1-Pad2_ LG L29K-F2J1-24-Z
U9 /Page3/RX_ISOLATED GND +3V3 XBEE_RX XBEE_TX /Page3/XBEE_VCC /Page3/XBEE_VCC /Page3/TX_ISOLATED TXB0102DCU
C43 +3V3 GND 0.1uF
R22 /Page3/XBEE_VCC GND 100K
U12 +3V3 XBEE_DEBUG_EN XBEE_TX XBEE_RX GND CC_UART0_TX CC_UART0_RX XBEE_DEBUG_RX XBEE_DEBUG_TX Net-_R28-Pad2_ FSUSB42MUX
R28 GND Net-_R28-Pad2_ 10k
C48 +3V3 GND 4.7uF
C50 +3V3 GND 0.1uF
R26 GND XBEE_DEBUG_EN 10k
U11 +3V3 GPS_DEBUG_EN GPS_TX GPS_RX GND CC_UART1_TX CC_UART1_RX GPS_DEBUG_RX GPS_DEBUG_TX Net-_R27-Pad2_ FSUSB42MUX
R27 GND Net-_R27-Pad2_ 10k
C47 +3V3 GND 4.7uF
C49 +3V3 GND 0.1uF
R25 GND GPS_DEBUG_EN 10k
J5 VBAT GND Conn_01x02
J1 VBUS VBUS VBUS VBUS GPS_DEBUG_EN GPS_DEBUG_RX GPS_DEBUG_TX GPS_RESET_N XBEE_DEBUG_TX XBEE_DEBUG_RX XBEE_DEBUG_EN XBEE_RESET XBEE_DTR XBEE_CTS CC_nRESET XBEE_RTS CC_UART0_TX CC_UART0_RX FLASH_CS FLASH_DIN FLASH_DOUT FLASH_CLK JTAG_TDO JTAG_TDI JTAG_TMS JTAG_TCK SOP0 SOP1 SOP2 NC_30 +3V3 +3V3 GND GND GND GND Conn_02x18_Odd_Even
U14 NC_31 NC_32 GND GND GND /GPS/TX_ISOLATED /GPS/RX_ISOLATED /GPS/GPS_VCC /GPS/GPS_VCC /GPS/GPS_VCC GPS_RESET_N NC_33 MAX-M8Q
U13 /GPS/RX_ISOLATED GND +3V3 GPS_RX GPS_TX /GPS/GPS_VCC /GPS/GPS_VCC /GPS/TX_ISOLATED TXB0102DCU
C52 +3V3 GND 0.1uF
R29 /GPS/GPS_VCC GND 100K
U15 +3V3 GND CC_GPIO8 Net-_C59-Pad1_ /GPS/GPS_VCC /GPS/GPS_VCC TPS22918
C59 Net-_C59-Pad1_ GND 0.001uF
R32 CC_GPIO8 GND 100K
C61 GND +3V3 1uF
C57 /GPS/GPS_VCC GND 22uF
U17 Net-_R38-Pad1_ Net-_R41-Pad1_ Net-_C67-Pad1_ GND Net-_R39-Pad1_ GND +3V3 +3V3 Net-_L9-Pad2_ GND Net-_L9-Pad1_ Net-_C64-Pad1_ Net-_C64-Pad1_ Net-_R38-Pad1_ GND TPS63070RNM
D2 Net-_D2-Pad1_ VBUS D
C64 Net-_C64-Pad1_ GND 10uF
C65 Net-_C64-Pad1_ GND 10uF
C66 Net-_C64-Pad1_ GND 10uF
C67 Net-_C67-Pad1_ GND 0.1uF
R38 Net-_R38-Pad1_ Net-_C64-Pad1_ 10k
C69 +3V3 GND 22uF
C70 +3V3 GND 22uF
C71 +3V3 GND 22uF
C68 +3V3 GND 10uF
R41 Net-_R41-Pad1_ +3V3 100k
R40 Net-_R39-Pad1_ +3V3 470k
R39 Net-_R39-Pad1_ GND 150k
L9 Net-_L9-Pad1_ Net-_L9-Pad2_ 1.5uH
D3 Net-_D2-Pad1_ VBAT D
R42 +3V3 Net-_D4-Pad2_ 330
D4 GND Net-_D4-Pad2_ LG L29K-F2J1-24-Z
U16 CC_ADC_CH2 CC_ADC_CH2 Net-_R34-Pad1_ GND Net-_R33-Pad1_ CC_ADC_CH3 CC_ADC_CH3 +3V3 OPA2340
C62 +3V3 GND 0.01uF
R34 Net-_R34-Pad1_ Net-_C64-Pad1_ ???
R36 Net-_C64-Pad1_ Net-_D2-Pad1_ 0.05
C63 +3V3 GND 0.01uF
R35 GND Net-_R34-Pad1_ ???
R37 Net-_R33-Pad1_ Net-_D2-Pad1_ ???
R33 Net-_R33-Pad1_ GND ???
.end
