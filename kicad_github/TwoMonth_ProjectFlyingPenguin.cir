.title KiCad schematic
U4 +3V3 Net-_R10-Pad1_ GND Net-_R10-Pad1_ Net-_R10-Pad1_ NC_01 /SDA /SCL MS561101BA03-50
J3 NC_02 /SPI0_SS_1 /SPI0_MOSI +3V3 /SPI0_SCK GND /SPI0_MOSI NC_03 NC_04 /uSD_CARD_DET GND Micro_SD_Card_Det
J1 /VBUS /USB_D- /USB_D+ NC_05 GND GND USB_B_Micro
M1 /PWM1_ELEV +5V GND Elevator_Servo
M2 /PWM0_FIN +5V GND Fin_Servo
J4 Net-_J4-Pad1_ GND GND Battery_Barrel_Jack
Q1 Net-_Q1-Pad1_ /USB_5V+ Net-_Q1-Pad3_ PFETDefaultA
Q4 /USB_5V+ +5V Net-_Q1-Pad1_ PFETAltB
Q2 /USB_5V+ Net-_C3-Pad1_ Net-_Q1-Pad1_ PFETAltA
U5 /RAW_BATTERY_V+ GND Net-_C3-Pad1_ LM2940_TO220
C1 /RAW_BATTERY_V+ GND 0.47uF
C3 Net-_C3-Pad1_ GND 22uF
R2 Net-_C3-Pad1_ GND 200K
D1 GND /USB_D+ /USB_D- /VBUS PRTR5V0U2X_215
U3 NC_06 GND +3V3 +3V3 Net-_R12-Pad1_ Net-_R13-Pad1_ NC_07 NC_08 Net-_C17-Pad1_ GND /~SYS_RESET NC_09 NC_10 NC_11 GND GND Net-_R11-Pad1_ GND /SCL /SDA NC_12 NC_13 NC_14 NC_15 GND /BNO_XOUT32 /BNO_XIN32 +3V3 BNO055
C2 /VBUS GND 1nF
C4 /USB_5V+ GND 1nF
R3 Net-_Q1-Pad1_ GND 100K
R1 /USB_5V+ GND 200K
FB1 /USB_5V+ /VBUS 470 @ 100Mhz (BLM18PG471SN1)
C5 +5V GND 10uF
U6 +5V GND +3V3 MIC29310
C6 +3V3 GND 10uF
Q3 Net-_Q1-Pad1_ +5V Net-_Q1-Pad3_ PFETDefaultB
C7 GND /XIN32 6.8pF
C8 /XOUT32 GND 6.8pF
U1 /XIN32 /XOUT32 /BATTV_ADC0 /THERM1_ADC1 GND /VDD_ANA /THERM2_ADC2 NC_16 NC_17 /SPI0_SS_0 /SPI0_MOSI /SPI0_SCK /SDA /SCL /PWM1_ELEV /Hotwire_GPO +3V3 GND /PWM0_FIN NC_18 /SPI0_SS_1 /uSD_CARD_DET NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 /USB_D- /USB_D+ GND +3V3 /FLIGHT_LED_CTRL NC_29 NC_30 /~SYS_RESET NC_31 GND +3V3 +3V3 /SWCLK /SWDIO NC_32 NC_33 ATSAMD21G18A-AUT
Q6 /Hotwire_GPO Net-_J5-Pad2_ GND FQP30N06L
Q5 /Hotwire_GPO Net-_C9-Pad1_ +5V FQP27P06
C9 Net-_C9-Pad1_ GND 4F
J5 Net-_C9-Pad1_ Net-_J5-Pad2_ Hotwire
R6 /Hotwire_GPO GND 10k
J2 +3V3 /SWDIO GND /SWCLK GND NC_34 NC_35 NC_36 GND /~SYS_RESET Conn_ARM_JTAG_SWD_10
R7 +3V3 /SDA 10k
R8 +3V3 /SCL 10k
U2 /SPI0_SS_0 /SPI0_MOSI Net-_R4-Pad1_ GND /SPI0_MOSI /SPI0_SCK Net-_R5-Pad1_ +3V3 AT25SF081-XMHD-X
R4 Net-_R4-Pad1_ +3V3 10k
R5 Net-_R5-Pad1_ +3V3 10k
Y1 /XIN32 /XOUT32 GND 32.768Khz
C16 +3V3 GND 0.1uF
Y2 /BNO_XIN32 /BNO_XOUT32 GND 32.768Khz
C18 /BNO_XOUT32 GND 22pF
C19 GND /BNO_XIN32 22pF
R12 Net-_R12-Pad1_ GND 10k
C17 Net-_C17-Pad1_ GND 0.1uF
R13 Net-_R13-Pad1_ GND 10k
R11 Net-_R11-Pad1_ GND 10k
R10 Net-_R10-Pad1_ +3V3 10k
R9 +3V3 /SWCLK 1k
C10 +3V3 GND 100nF
C11 +3V3 GND 1uF
C12 +3V3 GND 100nF
FB2 +3V3 /VDD_ANA 470 @ 100Mhz (BLM18PG471SN1)
C13 +3V3 GND 100nF
C14 /VDD_ANA GND 10uF
C15 /VDD_ANA GND 100nF
R14 Net-_D2-Pad1_ GND 330
D2 Net-_D2-Pad1_ +3V3 POWER_LED
J7 /RAW_BATTERY_V+ NC_37 Net-_J4-Pad1_ SS0750301F020P1A
R21 /RAW_BATTERY_V+ /BATTV_ADC0 10k
R22 /BATTV_ADC0 GND 3.2k
R23 +3V3 /THERM1_ADC1 20k
J10 GND /THERM1_ADC1 NTCLE100E3103JB0 (Therm 1)
R24 +3V3 /THERM2_ADC2 20k
J11 GND /THERM2_ADC2 NTCLE100E3103JB0 (Therm 2)
R19 +3V3 /~SYS_RESET 100k
R20 /~SYS_RESET Net-_R20-Pad2_ 39
J6 Net-_J6-Pad1_ /FLIGHT_LED_DRAIN FLIGHT_LED_0
J8 Net-_J8-Pad1_ /FLIGHT_LED_DRAIN FLIGHT_LED_1
J9 Net-_J9-Pad1_ /FLIGHT_LED_DRAIN FLIGHT_LED_2
Q7 /FLIGHT_LED_CTRL /FLIGHT_LED_DRAIN GND FQP30N06L
R15 Net-_J6-Pad1_ +3V3 25
R17 Net-_J8-Pad1_ +3V3 25
R18 Net-_J9-Pad1_ +3V3 25
R16 GND /FLIGHT_LED_CTRL 4.7k
S1 Net-_R20-Pad2_ GND ~RESET_BUTTON
.end
