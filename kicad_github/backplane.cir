.title KiCad schematic
J1 +5V +3V3 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 GND GND NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 +3V3 +5V Slot 1
J3 +5V +3V3 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 GND GND NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 +3V3 +5V Slot 3
J4 +5V +3V3 NC_109 NC_110 NC_111 NC_112 NC_113 NC_114 NC_115 NC_116 NC_117 NC_118 NC_119 NC_120 NC_121 NC_122 NC_123 NC_124 NC_125 NC_126 NC_127 NC_128 NC_129 NC_130 NC_131 NC_132 NC_133 NC_134 NC_135 GND GND NC_136 NC_137 NC_138 NC_139 NC_140 NC_141 NC_142 NC_143 NC_144 NC_145 NC_146 NC_147 NC_148 NC_149 NC_150 NC_151 NC_152 NC_153 NC_154 NC_155 NC_156 NC_157 NC_158 NC_159 NC_160 NC_161 NC_162 +3V3 +5V Slot 4
J5 +5V +3V3 NC_163 NC_164 NC_165 NC_166 NC_167 NC_168 NC_169 NC_170 NC_171 NC_172 NC_173 NC_174 NC_175 NC_176 NC_177 NC_178 NC_179 NC_180 NC_181 NC_182 NC_183 NC_184 NC_185 NC_186 NC_187 NC_188 NC_189 GND GND NC_190 NC_191 NC_192 NC_193 NC_194 NC_195 NC_196 NC_197 NC_198 NC_199 NC_200 NC_201 NC_202 NC_203 NC_204 NC_205 NC_206 NC_207 NC_208 NC_209 NC_210 NC_211 NC_212 NC_213 NC_214 NC_215 NC_216 +3V3 +5V Slot 5
J2 +5V +3V3 NC_217 NC_218 NC_219 NC_220 NC_221 NC_222 NC_223 NC_224 NC_225 NC_226 NC_227 NC_228 NC_229 NC_230 NC_231 NC_232 NC_233 NC_234 NC_235 NC_236 NC_237 NC_238 NC_239 NC_240 NC_241 NC_242 NC_243 GND GND NC_244 NC_245 NC_246 NC_247 NC_248 NC_249 NC_250 NC_251 NC_252 NC_253 NC_254 NC_255 NC_256 NC_257 NC_258 NC_259 NC_260 NC_261 NC_262 NC_263 NC_264 NC_265 NC_266 NC_267 NC_268 NC_269 NC_270 +3V3 +5V Slot 2
.end
