.title KiCad schematic
U1 /COL1 /COL2 /COL3 /COL4 /COL5 /COL6 /COL7 /COL8 /COL9 /COL10 /COL11 /COL12 /COL13 /COL14 /COL15 /COL16 /ROW1 /ROW2 /ROW3 /ROW4 /COL24 /COL23 /COL22 /COL21 /COL20 /COL19 /COL18 /COL17 /ROW5 /ROW6 /ROW7 /ROW8 8x8_RGB_LED_matrix
P1 /ROW8 /ROW7 /ROW6 /ROW5 /ROW4 /ROW3 /ROW2 /ROW1 CONN_02X04
P2 /COL1 /COL2 /COL3 /COL4 /COL5 /COL6 /COL7 /COL8 /COL9 /COL10 /COL11 /COL12 /COL13 /COL14 /COL15 /COL16 /COL17 /COL18 /COL19 /COL20 /COL21 /COL22 /COL23 /COL24 CONN_02X12
C2 +5VD GNDD 100nF
C1 +5VD GNDD 470uF
C3 +5VD GNDD 100nF
C4 +5VD GNDD 100nF
C5 +5VD GNDD 100nF
RP1 /COL20 /COL19 /COL18 /COL17 Net-_RP1-Pad5_ Net-_RP1-Pad6_ Net-_RP1-Pad7_ Net-_RP1-Pad8_ 180R
RP2 /COL24 /COL23 /COL22 /COL21 Net-_RP2-Pad5_ Net-_RP2-Pad6_ Net-_RP2-Pad7_ Net-_RP2-Pad8_ 180R
U3 +5VD /COL_IN Net-_RP2-Pad5_ Net-_RP2-Pad6_ Net-_RP2-Pad7_ Net-_RP2-Pad8_ +5VD GNDD Net-_U3-Pad9_ /STROBE_CLK Net-_RP1-Pad8_ Net-_RP1-Pad7_ Net-_RP1-Pad6_ Net-_RP1-Pad5_ /COL_CLK GNDD NPIC6C596
U2 Net-_RP7-Pad3_ Net-_RP7-Pad2_ Net-_RP7-Pad1_ Net-_RP8-Pad4_ Net-_RP8-Pad3_ Net-_RP8-Pad2_ Net-_RP8-Pad1_ GNDD /ROW_OUT +5VD /ROW_CLK /STROBE_CLK GNDD /ROW_IN Net-_RP7-Pad4_ +5VD 74HC595
RP3 /COL16 /COL15 /COL14 /COL13 Net-_RP3-Pad5_ Net-_RP3-Pad6_ Net-_RP3-Pad7_ Net-_RP3-Pad8_ 180R
RP4 /COL12 /COL11 /COL10 /COL9 Net-_RP4-Pad5_ Net-_RP4-Pad6_ Net-_RP4-Pad7_ Net-_RP4-Pad8_ 180R
U4 +5VD Net-_U3-Pad9_ Net-_RP3-Pad5_ Net-_RP3-Pad6_ Net-_RP3-Pad7_ Net-_RP3-Pad8_ +5VD GNDD Net-_U4-Pad9_ /STROBE_CLK Net-_RP4-Pad8_ Net-_RP4-Pad7_ Net-_RP4-Pad6_ Net-_RP4-Pad5_ /COL_CLK GNDD NPIC6C596
RP5 /COL8 /COL7 /COL6 /COL5 Net-_RP5-Pad5_ Net-_RP5-Pad6_ Net-_RP5-Pad7_ Net-_RP5-Pad8_ 180R
RP6 /COL4 /COL3 /COL2 /COL1 Net-_RP6-Pad5_ Net-_RP6-Pad6_ Net-_RP6-Pad7_ Net-_RP6-Pad8_ 180R
U5 +5VD Net-_U4-Pad9_ Net-_RP5-Pad5_ Net-_RP5-Pad6_ Net-_RP5-Pad7_ Net-_RP5-Pad8_ +5VD GNDD /COL_OUT /STROBE_CLK Net-_RP6-Pad8_ Net-_RP6-Pad7_ Net-_RP6-Pad6_ Net-_RP6-Pad5_ /COL_CLK GNDD NPIC6C596
Q1 +5VD /ROW8 Net-_Q1-Pad3_ 2SA1020
Q2 +5VD /ROW7 Net-_Q2-Pad3_ 2SA1020
Q4 +5VD /ROW5 Net-_Q4-Pad3_ 2SA1020
Q3 +5VD /ROW6 Net-_Q3-Pad3_ 2SA1020
Q5 +5VD /ROW4 Net-_Q5-Pad3_ 2SA1020
Q6 +5VD /ROW3 Net-_Q6-Pad3_ 2SA1020
Q8 +5VD /ROW1 Net-_Q8-Pad3_ 2SA1020
Q7 +5VD /ROW2 Net-_Q7-Pad3_ 2SA1020
P7 +5VD GNDD CONN_01X02
P8 +5VD GNDD CONN_01X02
P9 +5VD GNDD CONN_01X02
P10 +5VD GNDD CONN_01X02
RP7 Net-_RP7-Pad1_ Net-_RP7-Pad2_ Net-_RP7-Pad3_ Net-_RP7-Pad4_ Net-_Q2-Pad3_ Net-_Q1-Pad3_ Net-_Q4-Pad3_ Net-_Q3-Pad3_ 82R
RP8 Net-_RP8-Pad1_ Net-_RP8-Pad2_ Net-_RP8-Pad3_ Net-_RP8-Pad4_ Net-_Q5-Pad3_ Net-_Q6-Pad3_ Net-_Q7-Pad3_ Net-_Q8-Pad3_ 82R
P4 NC_01 /ROW_OUT /STROBE_CLK /ROW_CLK CONN_02X02
P3 /STROBE_CLK /ROW_CLK NC_02 /ROW_IN CONN_02X02
P6 /STROBE_CLK /COL_CLK NC_03 /COL_IN CONN_02X02
P5 NC_04 /COL_OUT /STROBE_CLK /COL_CLK CONN_02X02
.end
