.title KiCad schematic
D5 GND Net-_D5-Pad2_ LED
R14 5V Net-_Q1-Pad3_ 6.8k
Q1 sw1 Net-_Q1-Pad2_ Net-_Q1-Pad3_ 2N3904
R17 5V Net-_Q1-Pad2_ 2.2k
R26 sw1 Net-_D5-Pad2_ 200
H1 Tr1 Tr2 Tr3 Tr4 Tr5 Tr6 Tr7 Tr8 Tr9 NC_01 SDA SDC GND GND 5V 5V Expander
U4 NC_02 NC_03 NC_04 C4 C3 C2 5V GND NC_05 NC_06 C1 La Lb Lc Ld Le Lf Lg NC_07 5V NC_08 GND NC_09 NC_10 NC_11 NC_12 SDA SDC ATmega328P-PU
R4 C4 Net-_D1-Pad6_ 200
R3 C3 Net-_D1-Pad8_ 200
R2 C2 Net-_D1-Pad9_ 200
R1 C1 Net-_D1-Pad12_ 200
D1 Le Ld NC_13 Lc Lg Net-_D1-Pad6_ Lb Net-_D1-Pad8_ Net-_D1-Pad9_ Lf La Net-_D1-Pad12_ CC56-12CGKWA
U1 Net-_D2-Pad2_ Net-_D2-Pad1_ Net-_Q1-Pad3_ 5V Net-_Q1-Pad3_ Net-_R5-Pad1_ Net-_R5-Pad1_ Net-_R6-Pad1_ Net-_R6-Pad1_ Net-_Q1-Pad3_ GND Net-_Q1-Pad3_ Net-_R7-Pad1_ Net-_R7-Pad1_ TL074
U2 Net-_D3-Pad2_ Net-_D3-Pad1_ Net-_Q2-Pad3_ 5V Net-_Q2-Pad3_ Net-_R8-Pad1_ Net-_R8-Pad1_ Net-_R9-Pad1_ Net-_R9-Pad1_ Net-_Q2-Pad3_ GND Net-_Q2-Pad3_ Net-_R10-Pad1_ Net-_R10-Pad1_ TL074
U3 Net-_D4-Pad2_ Net-_D4-Pad1_ Net-_Q3-Pad3_ 5V Net-_Q3-Pad3_ Net-_R11-Pad1_ Net-_R11-Pad1_ Net-_R12-Pad1_ Net-_R12-Pad1_ Net-_Q3-Pad3_ GND Net-_Q3-Pad3_ Net-_R13-Pad1_ Net-_R13-Pad1_ TL074
SW2 Tr4 Tr5 sw2 Tr6 SW_SP3T
SW3 Tr7 Tr8 sw3 Tr9 SW_SP3T
SW1 Tr1 Tr2 sw1 Tr3 SW_SP3T
R5 Net-_R5-Pad1_ Net-_J1-Pad3_ 51
R6 Net-_R6-Pad1_ Net-_J2-Pad3_ 51
R7 Net-_R7-Pad1_ Net-_J3-Pad3_ 51
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED
R23 Net-_D2-Pad1_ GND 1k
R20 Net-_Q1-Pad3_ GND 10m
J1 GND NC_14 Net-_J1-Pad3_ PJ301M-12
J2 GND NC_15 Net-_J2-Pad3_ PJ301M-12
J3 GND NC_16 Net-_J3-Pad3_ PJ301M-12
D6 GND Net-_D6-Pad2_ LED
R15 5V Net-_Q2-Pad3_ 6.8k
Q2 sw2 Net-_Q2-Pad2_ Net-_Q2-Pad3_ 2N3904
R18 5V Net-_Q2-Pad2_ 2.2k
R27 sw2 Net-_D6-Pad2_ 200
R8 Net-_R8-Pad1_ Net-_J4-Pad3_ 51
R9 Net-_R9-Pad1_ Net-_J5-Pad3_ 51
R10 Net-_R10-Pad1_ Net-_J6-Pad3_ 51
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ LED
R24 Net-_D3-Pad1_ GND 1k
R21 Net-_Q2-Pad3_ GND 10m
J4 GND NC_17 Net-_J4-Pad3_ PJ301M-12
J5 GND NC_18 Net-_J5-Pad3_ PJ301M-12
J6 GND NC_19 Net-_J6-Pad3_ PJ301M-12
D7 GND Net-_D7-Pad2_ LED
R16 5V Net-_Q3-Pad3_ 6.8k
Q3 sw3 Net-_Q3-Pad2_ Net-_Q3-Pad3_ 2N3904
R19 5V Net-_Q3-Pad2_ 2.2k
R28 sw3 Net-_D7-Pad2_ 200
R11 Net-_R11-Pad1_ Net-_J7-Pad3_ 51
R12 Net-_R12-Pad1_ Net-_J8-Pad3_ 51
R13 Net-_R13-Pad1_ Net-_J9-Pad3_ 51
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R25 Net-_D4-Pad1_ GND 1k
R22 Net-_Q3-Pad3_ GND 10m
J7 GND NC_20 Net-_J7-Pad3_ PJ301M-12
J8 GND NC_21 Net-_J8-Pad3_ PJ301M-12
J9 GND NC_22 Net-_J9-Pad3_ PJ301M-12
.end
