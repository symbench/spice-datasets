.title KiCad schematic
J4 GND Net-_D7-Pad2_ NC_01 RESET_IN
D7 /SEQ_RESET_D Net-_D7-Pad2_ D
R3 GND Net-_D7-Pad2_ 10K
J2 GND Net-_D3-Pad2_ /INT_CLOCK_D EXT_CLOCK_IN
J5 GND Net-_D8-Pad2_ NC_02 ZERO_IN
D8 /SEQ_ZERO_D Net-_D8-Pad2_ D
R5 GND Net-_D8-Pad2_ 10K
SW1 +5V /EXT_CLOCK_D CLOCK_SW
R1 Net-_D3-Pad2_ GND 10K
D3 /EXT_CLOCK_D Net-_D3-Pad2_ D
J3 GND Net-_D6-Pad2_ Net-_J3-PadTN_ DIR_IN
R2 GND Net-_D6-Pad2_ 10K
D6 /SEQ_DIR_D Net-_D6-Pad2_ D
SW4 NC_03 +5V Net-_J3-PadTN_ SEQ_DIR
J1 GND Net-_J1-PadT_ NC_04 INT_CLOCK_OUT
R4 Net-_D4-Pad1_ Net-_J1-PadT_ 1K
D4 Net-_D4-Pad1_ /INT_CLOCK_D D
D1 GND /INT_CLOCK_D LED_INT_CLOCK
J6 GND Net-_J6-PadT_ NC_05 STEP_OUT
R6 Net-_D5-Pad1_ Net-_J6-PadT_ 1K
D5 Net-_D5-Pad1_ /STEP_PULSE_D D
D2 GND /STEP_PULSE_D LED_STEP_PULSE
J7 GND Net-_J7-PadT_ NC_06 EXT_RATE_CV
RV4 Net-_J7-PadT_ Net-_R10-Pad2_ GND RATE_ATT
R10 /EXT_RATE_A Net-_R10-Pad2_ 100K
R7 Net-_R7-Pad1_ /EXT_RATE_A 100K
RV1 +5V Net-_R7-Pad1_ GND RATE_OFFSET
J8 GND Net-_J8-PadT_ NC_07 EXT_POS_CV
RV5 Net-_J8-PadT_ Net-_R11-Pad2_ GND EXTPOS_ATT
R11 /EXT_POS_A Net-_R11-Pad2_ 100K
R8 Net-_R8-Pad1_ /EXT_POS_A 100K
RV2 +5V Net-_R8-Pad1_ GND EXTPOS_OFFSET
J9 GND Net-_J9-PadT_ NC_08 PULSELEN_CV
RV6 Net-_J9-PadT_ Net-_R12-Pad2_ GND PULSELEN_ATT
R12 /PULSELEN_A Net-_R12-Pad2_ 100K
R9 Net-_R9-Pad1_ /PULSELEN_A 100K
RV3 +5V Net-_R9-Pad1_ GND PULSELEN_OFFSET
J11 GND /OFFSET_B NC_09 OFFSET_B
J12 GND /OFFSET_C NC_10 OFFSET_C
J13 GND /OFFSET_D NC_11 OFFSET_D
J14 GND /OUTPUT_A NC_12 OUTPUT_A
J15 GND /OUTPUT_B NC_13 OUTPUT_B
J16 GND /OUTPUT_C NC_14 OUTPUT_C
J17 GND /OUTPUT_D NC_15 OUTPUT_D
J18 GND /OUTPUT_E NC_16 OUTPUT_E
J19 GND /OUTPUT_F NC_17 OUTPUT_F
SW2 +5V /SEQ_RESET_D RESET_SW
SW3 /SEQ_ZERO_D +5V ZERO_SW
H1 GND M3
H2 GND M3
H3 GND M3
H4 GND M3
J10 GND /OFFSET_A NC_18 OFFSET_A
J20 GND NC_19 /STEP_PULSE_D /INT_CLOCK_D /EXT_CLOCK_D /OUTPUT_F /OUTPUT_E /OUTPUT_D /OFFSET_D /OUTPUT_C /OFFSET_C /OUTPUT_B /OFFSET_B /OUTPUT_A /OFFSET_A GND TOP
J21 GND NC_20 NC_21 /SEQ_RESET_D /SEQ_ZERO_D /SEQ_DIR_D +5V GND BOTTOM
J22 /EXT_POS_A /PULSELEN_A /EXT_RATE_A GND RIGHT
.end
