.title KiCad schematic
P2 NC_01 NC_02 NC_03 +3V3 +5V GND GND NC_04 Power
P3 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 Analog
P4 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 Analog
P6 /7_**_ /6_**_ /5_**_ /4_**_ /3_**_ /2_**_ NC_21 NC_22 PWM
P7 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 Communication
P5 NC_31 NC_32 NC_33 GND NC_34 NC_35 NC_36 /10_**_ /9_**_ /8_**_ PWM
P1 GND GND NC_37 /53_SS_ NC_38 /51_MOSI_ NC_39 NC_40 NC_41 /47 NC_42 NC_43 NC_44 /43 NC_45 /41 /38 /39 /36 /37 /34 /35 /32 /33 /30 /31 /28 /29 /26 /27 /24 /25 /22 /23 +5V +5V Digital
P8 NC_46 CONN_1
P9 NC_47 CONN_1
P10 NC_48 CONN_1
P11 NC_49 CONN_1
P12 NC_50 CONN_1
P13 NC_51 CONN_1
P14 /34 +6V GND CONN_01X03
P20 /36 +6V GND CONN_01X03
P26 /38 +6V GND CONN_01X03
P32 /10_**_ +6V GND CONN_01X03
P35 /9_**_ +6V GND CONN_01X03
P38 /8_**_ +6V GND CONN_01X03
P15 /28 +6V GND CONN_01X03
P21 /30 +6V GND CONN_01X03
P27 /32 +6V GND CONN_01X03
P33 /7_**_ +6V GND CONN_01X03
P36 /6_**_ +6V GND CONN_01X03
P39 /5_**_ +6V GND CONN_01X03
P18 /27 +6V GND CONN_01X03
P24 /25 +6V GND CONN_01X03
P30 /23 +6V GND CONN_01X03
P16 /22 +6V GND CONN_01X03
P22 /24 +6V GND CONN_01X03
P28 /26 +6V GND CONN_01X03
P34 /4_**_ +6V GND CONN_01X03
P37 /3_**_ +6V GND CONN_01X03
P40 /2_**_ +6V GND CONN_01X03
P19 /29 +6V GND CONN_01X03
P25 /31 +6V GND CONN_01X03
P31 /33 +6V GND CONN_01X03
P17 NC_52 +6V GND CONN_01X03
C1 +6V GND CP1
P23 GND /51_MOSI_ /53_SS_ +5V CONN_01X04
P41 GND /39 /41 +5V CONN_01X04
P29 GND /43 /47 +5V CONN_01X04
P42 GND /35 /37 +5V CONN_01X04
P43 GND +6V CONN_01X02
.end
