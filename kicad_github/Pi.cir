.title KiCad schematic
J1 +3V3 +5V /GPIO2 +5V /GPIO3 GND GPIO4 GPIO14 GND GPIO15 GPIO17 GPIO18 GPIO27 GND GPIO22 GPIO23 +3V3 GPIO24 GPIO10 GND GPIO9 GPIO25 GPIO11 GPIO8 GND GPIO7 NC_01 NC_02 GPIO5 GND GPIO6 GPIO12 GPIO13 GND GPIO19 GPIO16 GPIO26 GPIO20 GND GPIO21 RasPi
C1 +5V GND 220u/10V
U1 GPB0 GPB1 GPB2 GPB3 GPB4 GPB5 GPB6 GPB7 +3V3 GND NC_03 /GPIO3 /GPIO2 NC_04 NC_05 NC_06 NC_07 Net-_C2-Pad1_ NC_08 GPIO15 GPA0 GPA1 GPA2 GPA3 GPA4 GPA5 GPA6 GPA7 MCP23017_SO
C3 +3V3 GND 10u
C2 Net-_C2-Pad1_ GND 1n
R2 +3V3 Net-_C2-Pad1_ 100k
RN1 +3V3 GPA0 GPA1 GPA2 GPA3 GPA4 GPA5 GPA6 GPA7 10k
RN2 +3V3 GPB0 GPB1 GPB2 GPB3 GPB4 GPB5 GPB6 GPB7 10k
RN3 +3V3 GPIO21 GPIO26 GPIO20 GPIO19 GPIO16 GPIO13 GPIO12 GPIO6 10k
RN4 +3V3 GPIO5 GPIO7 GPIO11 GPIO8 GPIO9 GPIO25 GPIO10 GPIO24 10k
R3 +3V3 /GPIO2 10k
R1 /GPIO3 +3V3 10k
RN5 +3V3 GPIO22 GPIO23 GPIO27 GPIO18 GPIO17 GPIO15 GPIO14 GPIO4 10k
SW9 GND GPA0 SW_Push
SW8 GND GPA1 SW_Push
SW7 GND GPA2 SW_Push
SW6 GND GPA3 SW_Push
SW5 GND GPB4 SW_Push
SW4 GND GPB5 SW_Push
SW3 GND GPB6 SW_Push
SW2 GND GPB7 SW_Push
SW17 GND GPB0 SW_Push
SW16 GND GPB1 SW_Push
SW15 GND GPB2 SW_Push
SW14 GND GPB3 SW_Push
SW13 GND GPA4 SW_Push
SW12 GND GPA5 SW_Push
SW11 GND GPA6 SW_Push
SW10 GND GPA7 SW_Push
ENC2 GPIO20 GPIO26 GND GPIO21 GND Rotary_Encoder_Switch
ENC3 GPIO16 GPIO13 GND GPIO19 GND Rotary_Encoder_Switch
ENC4 GPIO7 GPIO8 GND GPIO12 GND Rotary_Encoder_Switch
ENC5 GPIO27 GPIO17 GND GPIO22 GND Rotary_Encoder_Switch
J2 +5V GPIO14 GPIO18 GND ENC1
J7 +3V3 +5V /GPIO2 /GPIO3 GPIO15 GND Conn_01x06
J8 GND GPIO18 +5V GPIO14 GND ENC1a
.end
