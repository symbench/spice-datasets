.title KiCad schematic
SW1 col0 Net-_D1-Pad2_ KEYSW
D1 row0 Net-_D1-Pad2_
SW2 col1 Net-_D2-Pad2_ KEYSW
D2 row0 Net-_D2-Pad2_
SW3 col2 Net-_D3-Pad2_ KEYSW
D3 row0 Net-_D3-Pad2_
SW4 col3 Net-_D4-Pad2_ KEYSW
D4 row0 Net-_D4-Pad2_
SW5 col4 Net-_D5-Pad2_ KEYSW
D5 row0 Net-_D5-Pad2_
SW6 col5 Net-_D6-Pad2_ KEYSW
D6 row0 Net-_D6-Pad2_
SW7 col6 Net-_D7-Pad2_ KEYSW
D7 row0 Net-_D7-Pad2_
SW8 col7 Net-_D8-Pad2_ KEYSW
D8 row0 Net-_D8-Pad2_
SW9 col8 Net-_D9-Pad2_ KEYSW
D9 row0 Net-_D9-Pad2_
SW10 col9 Net-_D10-Pad2_ KEYSW
D10 row0 Net-_D10-Pad2_
SW11 col10 Net-_D11-Pad2_ KEYSW
D11 row0 Net-_D11-Pad2_
SW12 col11 Net-_D12-Pad2_ KEYSW
D12 row0 Net-_D12-Pad2_
SW13 col12 Net-_D13-Pad2_ KEYSW
D13 row0 Net-_D13-Pad2_
SW14 col13 Net-_D14-Pad2_ KEYSW
D14 row0 Net-_D14-Pad2_
SW15 col14 Net-_D15-Pad2_ KEYSW
D15 row0 Net-_D15-Pad2_
SW16 col0 Net-_D16-Pad2_ KEYSW
D16 row1 Net-_D16-Pad2_
SW17 col1 Net-_D17-Pad2_ KEYSW
D17 row1 Net-_D17-Pad2_
SW18 col2 Net-_D18-Pad2_ KEYSW
D18 row1 Net-_D18-Pad2_
SW19 col3 Net-_D19-Pad2_ KEYSW
D19 row1 Net-_D19-Pad2_
SW20 col4 Net-_D20-Pad2_ KEYSW
D20 row1 Net-_D20-Pad2_
SW21 col5 Net-_D21-Pad2_ KEYSW
D21 row1 Net-_D21-Pad2_
SW22 col6 Net-_D22-Pad2_ KEYSW
D22 row1 Net-_D22-Pad2_
SW23 col7 Net-_D23-Pad2_ KEYSW
D23 row1 Net-_D23-Pad2_
SW24 col8 Net-_D24-Pad2_ KEYSW
D24 row1 Net-_D24-Pad2_
SW25 col9 Net-_D25-Pad2_ KEYSW
D25 row1 Net-_D25-Pad2_
SW26 col10 Net-_D26-Pad2_ KEYSW
D26 row1 Net-_D26-Pad2_
SW27 col11 Net-_D27-Pad2_ KEYSW
D27 row1 Net-_D27-Pad2_
SW28 col12 Net-_D28-Pad2_ KEYSW
D28 row1 Net-_D28-Pad2_
SW29 col13 Net-_D29-Pad2_ KEYSW
D29 row1 Net-_D29-Pad2_
SW30 col14 Net-_D30-Pad2_ KEYSW
D30 row1 Net-_D30-Pad2_
SW31 col0 Net-_D31-Pad2_ KEYSW
D31 row2 Net-_D31-Pad2_
SW32 col1 Net-_D32-Pad2_ KEYSW
D32 row2 Net-_D32-Pad2_
SW33 col2 Net-_D33-Pad2_ KEYSW
D33 row2 Net-_D33-Pad2_
SW34 col3 Net-_D34-Pad2_ KEYSW
D34 row2 Net-_D34-Pad2_
SW35 col4 Net-_D35-Pad2_ KEYSW
D35 row2 Net-_D35-Pad2_
SW36 col5 Net-_D36-Pad2_ KEYSW
D36 row2 Net-_D36-Pad2_
SW37 col6 Net-_D37-Pad2_ KEYSW
D37 row2 Net-_D37-Pad2_
SW38 col7 Net-_D38-Pad2_ KEYSW
D38 row2 Net-_D38-Pad2_
SW39 col8 Net-_D39-Pad2_ KEYSW
D39 row2 Net-_D39-Pad2_
SW40 col9 Net-_D40-Pad2_ KEYSW
D40 row2 Net-_D40-Pad2_
SW41 col10 Net-_D41-Pad2_ KEYSW
D41 row2 Net-_D41-Pad2_
SW42 col11 Net-_D42-Pad2_ KEYSW
D42 row2 Net-_D42-Pad2_
SW43 col13 Net-_D43-Pad2_ KEYSW
D43 row2 Net-_D43-Pad2_
SW44 col14 Net-_D44-Pad2_ KEYSW
D44 row2 Net-_D44-Pad2_
SW45 col0 Net-_D45-Pad2_ KEYSW
D45 row3 Net-_D45-Pad2_
SW46 col2 Net-_D46-Pad2_ KEYSW
D46 row3 Net-_D46-Pad2_
SW47 col3 Net-_D47-Pad2_ KEYSW
D47 row3 Net-_D47-Pad2_
SW48 col4 Net-_D48-Pad2_ KEYSW
D48 row3 Net-_D48-Pad2_
SW49 col5 Net-_D49-Pad2_ KEYSW
D49 row3 Net-_D49-Pad2_
SW50 col6 Net-_D50-Pad2_ KEYSW
D50 row3 Net-_D50-Pad2_
SW51 col7 Net-_D51-Pad2_ KEYSW
D51 row3 Net-_D51-Pad2_
SW52 col8 Net-_D52-Pad2_ KEYSW
D52 row3 Net-_D52-Pad2_
SW53 col9 Net-_D53-Pad2_ KEYSW
D53 row3 Net-_D53-Pad2_
SW54 col10 Net-_D54-Pad2_ KEYSW
D54 row3 Net-_D54-Pad2_
SW55 col11 Net-_D55-Pad2_ KEYSW
D55 row3 Net-_D55-Pad2_
SW56 col12 Net-_D56-Pad2_ KEYSW
D56 row3 Net-_D56-Pad2_
SW57 col13 Net-_D57-Pad2_ KEYSW
D57 row3 Net-_D57-Pad2_
SW58 col14 Net-_D58-Pad2_ KEYSW
D58 row3 Net-_D58-Pad2_
SW59 col0 Net-_D59-Pad2_ KEYSW
D59 row4 Net-_D59-Pad2_
SW60 col1 Net-_D60-Pad2_ KEYSW
D60 row4 Net-_D60-Pad2_
SW61 col2 Net-_D61-Pad2_ KEYSW
D61 row4 Net-_D61-Pad2_
SW62 col6 Net-_D62-Pad2_ KEYSW
D62 row4 Net-_D62-Pad2_
SW63 col9 Net-_D63-Pad2_ KEYSW
D63 row4 Net-_D63-Pad2_
SW64 col10 Net-_D64-Pad2_ KEYSW
D64 row4 Net-_D64-Pad2_
SW65 col12 Net-_D65-Pad2_ KEYSW
D65 row4 Net-_D65-Pad2_
SW66 col13 Net-_D66-Pad2_ KEYSW
D66 row4 Net-_D66-Pad2_
SW67 col14 Net-_D67-Pad2_ KEYSW
D67 row4 Net-_D67-Pad2_
SW68 col11 Net-_D68-Pad2_ KEYSW
D68 row4 Net-_D68-Pad2_
R1 GND Net-_R1-Pad2_ 5.1k
R2 Net-_R2-Pad1_ GND 5.1k
USB1 GND VCC Net-_R1-Pad2_ Net-_D70-Pad1_ Net-_D69-Pad1_ NC_01 VCC GND GND VCC Net-_R2-Pad1_ Net-_D70-Pad1_ Net-_D69-Pad1_ NC_02 VCC GND GND USB_C_GCT_USB4085
R3 D- Net-_D69-Pad1_ 75R
R4 D+ Net-_D70-Pad1_ 75R
Y1 Net-_C1-Pad1_ Net-_C2-Pad1_ Crystal
C2 Net-_C2-Pad1_ GND 22p
C1 Net-_C1-Pad1_ GND 22p
D69 Net-_D69-Pad1_ GND 3.6V
D70 Net-_D70-Pad1_ GND 3.6V
R5 +5V Net-_D69-Pad1_ 1.5k
F1 +5V VCC 500mA
C3 +5V GND 4.7u
C4 +5V GND 0.1u
C5 +5V GND 0.1u
RESET1 GND reset RESET
LED1 Net-_LED1-Pad1_ +5V POWER
R6 Net-_LED1-Pad1_ GND 1.5K
R7 +5V reset 10k
BOOT1 GND boot BOOT
J1 MISO +5V SCK MOSI reset GND AVR-ISP-6
SW69 col0 Net-_D31-Pad2_ KEYSW
SW70 col0 Net-_D59-Pad2_ KEYSW
SW71 col2 Net-_D61-Pad2_ KEYSW
SW72 col6 Net-_D62-Pad2_ KEYSW
SW73 col9 Net-_D63-Pad2_ KEYSW
SW74 col10 Net-_D64-Pad2_ KEYSW
U1 row4 row2 row0 col1 col3 MOSI MISO SCK reset +5V GND Net-_C2-Pad1_ Net-_C1-Pad1_ NC_03 NC_04 D+ D- boot col5 col6 col14 col13 col12 col11 col10 col9 col8 col7 NC_05 +5V GND NC_06 NC_07 NC_08 NC_09 col4 col2 col0 row1 row3 ATmega32A-PU
.end
