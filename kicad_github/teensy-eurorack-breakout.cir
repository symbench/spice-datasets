.title KiCad schematic
J1 GND +5V /TFT_SCK /TFT_MOSI +5V /TFT_DC /TFT_CS +5V Conn_01x08
JIN1 /VGND1 /VIN1 GND AudioJack2_SwitchT
JIN2 /VGND2 /VIN2 GND AudioJack2_SwitchT
JIN3 /VGND3 /VIN3 GND AudioJack2_SwitchT
JIN4 /VGND4 /VIN4 GND AudioJack2_SwitchT
JIN6 /VGND6 /VIN6 GND AudioJack2_SwitchT
JIN7 /VGND7 /VIN7 GND AudioJack2_SwitchT
JIN8 /VGND8 /VIN8 GND AudioJack2_SwitchT
JOUT1 GND /VOUT1 NC_01 AudioJack2_SwitchT
JOUT2 GND /VOUT2 NC_02 AudioJack2_SwitchT
JOUT3 GND /VOUT3 NC_03 AudioJack2_SwitchT
JOUT4 GND /VOUT4 NC_04 AudioJack2_SwitchT
JOUT5 GND /VOUT5 NC_05 AudioJack2_SwitchT
JOUT6 GND /VOUT6 NC_06 AudioJack2_SwitchT
JOUT7 GND /VOUT7 NC_07 AudioJack2_SwitchT
JOUT8 GND /VOUT8 NC_08 AudioJack2_SwitchT
JIN5 /VGND5 /VIN5 GND AudioJack2_SwitchT
MIDI_IN1 NC_09 /MIDI_RX_PIN2 NC_10 /MIDI_RX_PIN4 NC_11 DIN-5
MIDI_OUT1 NC_12 /MIDI_TX_PIN2 NC_13 /MIDI_TX_PIN4 NC_14 DIN-5
SDCARD1 Net-_FPC_SD1-Pad8_ Net-_FPC_SD1-Pad7_ Net-_FPC_SD1-Pad6_ Net-_FPC_SD1-Pad5_ Net-_FPC_SD1-Pad4_ Net-_FPC_SD1-Pad3_ Net-_FPC_SD1-Pad2_ Net-_FPC_SD1-Pad1_ GND GND YAMAICHI_SD_CARD
JBUSBA1 Net-_JBUSBA1-Pad1_ Net-_JBUSBA1-Pad2_ Net-_JBUSBA1-Pad3_ Net-_JBUSBA1-Pad4_ Conn_01x04
JBUSBB1 GND Net-_JBUSBB1-Pad2_ Net-_JBUSBB1-Pad3_ Net-_JBUSBB1-Pad4_ Conn_01x04
USBA1 Net-_JBUSBA1-Pad4_ Net-_JBUSBA1-Pad3_ Net-_JBUSBA1-Pad2_ Net-_JBUSBA1-Pad1_ NC_15 NC_16 USB-A-S-X-X-VT
USBB1 Net-_JBUSBB1-Pad4_ Net-_JBUSBB1-Pad3_ Net-_JBUSBB1-Pad2_ GND NC_17 NC_18 61400413321
FPC_SD1 Net-_FPC_SD1-Pad1_ Net-_FPC_SD1-Pad2_ Net-_FPC_SD1-Pad3_ Net-_FPC_SD1-Pad4_ Net-_FPC_SD1-Pad5_ Net-_FPC_SD1-Pad6_ Net-_FPC_SD1-Pad7_ Net-_FPC_SD1-Pad8_ GND GND 1734592-8
JIN9 GND /DIN1 GND AudioJack2_SwitchT
JIN10 GND /DIN2 GND AudioJack2_SwitchT
SW1 /ENC1A /ENC1B GND /ENC1SW GND Rotary_Encoder_Switch
J2 GND /VIN1 /VGND1 /VIN2 /VGND2 /VIN3 /VGND3 /VIN4 /VGND4 /VIN5 /VGND5 /VIN6 /VGND6 /VIN7 /VGND7 /MIDI_TX_PIN2 /MIDI_TX_PIN4 /DIN1 /DIN2 NC_19 Conn_01x20
J3 /VIN8 /VGND8 /VOUT1 /VOUT2 /VOUT3 /VOUT4 /VOUT5 /VOUT6 /VOUT7 /VOUT8 /TFT_SCK /TFT_MOSI /TFT_DC /TFT_CS /MIDI_RX_PIN2 /MIDI_RX_PIN4 /ENC1A /ENC1B /ENC1SW +5V Conn_01x20
JX1 GND GND GND GND Conn_01x04
JX2 GND GND GND GND Conn_01x04
.end
