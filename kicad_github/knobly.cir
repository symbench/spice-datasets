.title KiCad schematic
U1 NC_01 COL9 COL11 COL13 COL15 GND VCC COL0 COL2 COL4 COL6 NC_02 NC_03 COL8 COL10 COL12 COL14 Net-_J1-Pad1_ ROW0 ROW1 ROW2 ROW3 ROW4 ROW5 ENC0 ENC1 ENC2 VCC GND Net-_C3-Pad2_ Net-_C2-Pad1_ NC_04 NC_05 NC_06 ROW6 NC_07 Net-_C1-Pad1_ COL1 COL3 COL5 COL7 Net-_P1-Pad2_ Net-_P1-Pad3_ NC_08 PIC18F4550_TQFP
C1 Net-_C1-Pad1_ GND 470n
P1 VCC Net-_P1-Pad2_ Net-_P1-Pad3_ GND GND USB_B
J1 Net-_J1-Pad1_ VCC GND COL14 COL12 NC_09 GND GND RJ12
Y1 Net-_C2-Pad1_ Net-_C3-Pad2_ 20Mhz
C2 Net-_C2-Pad1_ GND 15p
C3 GND Net-_C3-Pad2_ 15p
C4 GND VCC 100n
C5 GND VCC 100n
R1 VCC Net-_J1-Pad1_ 50k
C6 VCC GND 10u
D02 ROW0 Net-_D02-Pad2_ D_Small
D03 ROW0 Net-_D03-Pad2_ D_Small
D00 ROW0 Net-_D00-Pad2_ D_Small
D01 ROW0 Net-_D01-Pad2_ D_Small
D06 ROW0 Net-_D06-Pad2_ D_Small
D07 ROW0 Net-_D07-Pad2_ D_Small
D04 ROW0 Net-_D04-Pad2_ D_Small
D05 ROW0 Net-_D05-Pad2_ D_Small
D08 ROW0 Net-_D08-Pad2_ D_Small
D12 ROW1 Net-_D12-Pad2_ D_Small
D13 ROW1 Net-_D13-Pad2_ D_Small
D10 ROW1 Net-_D10-Pad2_ D_Small
D11 ROW1 Net-_D11-Pad2_ D_Small
D16 ROW1 Net-_D16-Pad2_ D_Small
D17 ROW1 Net-_D17-Pad2_ D_Small
D14 ROW1 Net-_D14-Pad2_ D_Small
D15 ROW1 Net-_D15-Pad2_ D_Small
D110 ROW1 Net-_D110-Pad2_ D_Small
D111 ROW1 Net-_D111-Pad2_ D_Small
D18 ROW1 Net-_D18-Pad2_ D_Small
D19 ROW1 Net-_D19-Pad2_ D_Small
D114 ROW1 Net-_D114-Pad2_ D_Small
D115 ROW1 Net-_D115-Pad2_ D_Small
D112 ROW1 Net-_D112-Pad2_ D_Small
D113 ROW1 Net-_D113-Pad2_ D_Small
D22 ROW2 Net-_D22-Pad2_ D_Small
D23 ROW2 Net-_D23-Pad2_ D_Small
D20 ROW2 Net-_D20-Pad2_ D_Small
D21 ROW2 Net-_D21-Pad2_ D_Small
D26 ROW2 Net-_D26-Pad2_ D_Small
D27 ROW2 Net-_D27-Pad2_ D_Small
D24 ROW2 Net-_D24-Pad2_ D_Small
D25 ROW2 Net-_D25-Pad2_ D_Small
D210 ROW2 Net-_D210-Pad2_ D_Small
D211 ROW2 Net-_D211-Pad2_ D_Small
D28 ROW2 Net-_D28-Pad2_ D_Small
D29 ROW2 Net-_D29-Pad2_ D_Small
D212 ROW2 Net-_D212-Pad2_ D_Small
D32 ROW3 Net-_D32-Pad2_ D_Small
D33 ROW3 Net-_D33-Pad2_ D_Small
D30 ROW3 Net-_D30-Pad2_ D_Small
D31 ROW3 Net-_D31-Pad2_ D_Small
D36 ROW3 Net-_D36-Pad2_ D_Small
D37 ROW3 Net-_D37-Pad2_ D_Small
D34 ROW3 Net-_D34-Pad2_ D_Small
D35 ROW3 Net-_D35-Pad2_ D_Small
D310 ROW3 Net-_D310-Pad2_ D_Small
D311 ROW3 Net-_D311-Pad2_ D_Small
D38 ROW3 Net-_D38-Pad2_ D_Small
D39 ROW3 Net-_D39-Pad2_ D_Small
D314 ROW3 Net-_D314-Pad2_ D_Small
D315 ROW3 Net-_D315-Pad2_ D_Small
D312 ROW3 Net-_D312-Pad2_ D_Small
D313 ROW3 Net-_D313-Pad2_ D_Small
D09 ROW0 Net-_D09-Pad2_ D_Small
SWE00 Net-_DE02-Pad1_ COL5 Net-_D15-Pad2_ ENC0 Net-_DE03-Pad1_ Net-_DE00-Pad1_ ENC0 Net-_DE01-Pad1_ Concentric
SWE04 Net-_DE06-Pad1_ COL6 Net-_D16-Pad2_ ENC0 Net-_DE07-Pad1_ Net-_DE04-Pad1_ ENC0 Net-_DE05-Pad1_ Concentric
SWE08 Net-_DE010-Pad1_ COL13 Net-_D113-Pad2_ ENC0 Net-_DE011-Pad1_ Net-_DE08-Pad1_ ENC0 Net-_DE09-Pad1_ Concentric
SWE012 Net-_DE014-Pad1_ COL14 Net-_D114-Pad2_ ENC0 Net-_DE015-Pad1_ Net-_DE012-Pad1_ ENC0 Net-_DE013-Pad1_ Concentric
SWE10 Net-_DE11-Pad1_ ENC1 Net-_DE10-Pad1_ Net-_D12-Pad2_ COL2 Encoder
SWE12 Net-_DE13-Pad1_ ENC1 Net-_DE12-Pad1_ Net-_D18-Pad2_ COL8 Encoder
SWE14 Net-_DE15-Pad1_ ENC1 Net-_DE14-Pad1_ Net-_D112-Pad2_ COL12 Encoder
SWE16 Net-_DE17-Pad1_ ENC1 Net-_DE16-Pad1_ Net-_D115-Pad2_ COL15 Encoder
SWE18 Net-_DE110-Pad1_ COL12 Net-_D212-Pad2_ ENC1 Net-_DE111-Pad1_ Net-_DE18-Pad1_ ENC1 Net-_DE19-Pad1_ Concentric
SWE24 Net-_DE25-Pad1_ ENC2 Net-_DE24-Pad1_ Net-_D310-Pad2_ COL10 Encoder
SWE26 Net-_DE27-Pad1_ ENC2 Net-_DE26-Pad1_ Net-_D311-Pad2_ COL11 Encoder
SWE28 Net-_DE29-Pad1_ ENC2 Net-_DE28-Pad1_ Net-_D312-Pad2_ COL12 Encoder
SWE210 Net-_DE211-Pad1_ ENC2 Net-_DE210-Pad1_ Net-_D313-Pad2_ COL13 Encoder
SWE212 Net-_DE213-Pad1_ ENC2 Net-_DE212-Pad1_ Net-_D314-Pad2_ COL14 Encoder
SWE214 Net-_DE215-Pad1_ ENC2 Net-_DE214-Pad1_ Net-_D315-Pad2_ COL15 Encoder
SW414 COL15 Net-_D414-Pad2_ COL14 FLIP
D414 ROW4 Net-_D414-Pad2_ D_Small
SW514 COL15 Net-_D514-Pad2_ COL14 FLIP
D514 ROW5 Net-_D514-Pad2_ D_Small
SW614 COL15 Net-_D614-Pad2_ COL14 FLIP
D614 ROW6 Net-_D614-Pad2_ D_Small
SW412 COL13 Net-_D412-Pad2_ COL12 FLIP
D412 ROW4 Net-_D412-Pad2_ D_Small
SW512 COL13 Net-_D512-Pad2_ COL12 FLIP
D512 ROW5 Net-_D512-Pad2_ D_Small
SW612 COL13 Net-_D612-Pad2_ COL12 FLIP
D612 ROW6 Net-_D612-Pad2_ D_Small
SW410 COL11 Net-_D410-Pad2_ COL10 FLIP
D410 ROW4 Net-_D410-Pad2_ D_Small
SW510 COL11 Net-_D510-Pad2_ COL10 FLIP
D510 ROW5 Net-_D510-Pad2_ D_Small
SW610 COL11 Net-_D610-Pad2_ COL10 FLIP
D610 ROW6 Net-_D610-Pad2_ D_Small
SW48 COL9 Net-_D48-Pad2_ COL8 FLIP
D48 ROW4 Net-_D48-Pad2_ D_Small
SW58 COL9 Net-_D58-Pad2_ COL8 FLIP
D58 ROW5 Net-_D58-Pad2_ D_Small
SW68 COL9 Net-_D68-Pad2_ COL8 FLIP
D68 ROW6 Net-_D68-Pad2_ D_Small
SW46 COL7 Net-_D46-Pad2_ COL6 FLIP
D46 ROW4 Net-_D46-Pad2_ D_Small
SW56 COL7 Net-_D56-Pad2_ COL6 FLIP
D56 ROW5 Net-_D56-Pad2_ D_Small
SW66 COL7 Net-_D66-Pad2_ COL6 FLIP
D66 ROW6 Net-_D66-Pad2_ D_Small
SW44 COL5 Net-_D44-Pad2_ COL4 FLIP
D44 ROW4 Net-_D44-Pad2_ D_Small
SW54 COL5 Net-_D54-Pad2_ COL4 FLIP
D54 ROW5 Net-_D54-Pad2_ D_Small
SW64 COL5 Net-_D64-Pad2_ COL4 FLIP
D64 ROW6 Net-_D64-Pad2_ D_Small
D40 ROW4 Net-_D40-Pad2_ D_Small
D41 ROW4 Net-_D41-Pad2_ D_Small
SW00 COL0 Net-_D00-Pad2_ TACT
SW01 COL1 Net-_D01-Pad2_ TACT
SW02 COL2 Net-_D02-Pad2_ TACT
SW03 COL3 Net-_D03-Pad2_ TACT
SW04 COL4 Net-_D04-Pad2_ TACT
SW05 COL5 Net-_D05-Pad2_ TACT
SW06 COL6 Net-_D06-Pad2_ TACT
SW14 COL4 Net-_D14-Pad2_ TACT
SW13 COL3 Net-_D13-Pad2_ TACT
SW11 COL1 Net-_D11-Pad2_ TACT
SW10 COL0 Net-_D10-Pad2_ TACT
SW20 COL0 Net-_D20-Pad2_ TACT
SW21 COL1 Net-_D21-Pad2_ TACT
SW22 COL2 Net-_D22-Pad2_ TACT
SW23 COL3 Net-_D23-Pad2_ TACT
SW24 COL4 Net-_D24-Pad2_ TACT
SW25 COL5 Net-_D25-Pad2_ TACT
SW26 COL6 Net-_D26-Pad2_ TACT
SW30 COL0 Net-_D30-Pad2_ TACT
SW31 COL1 Net-_D31-Pad2_ TACT
SW32 COL2 Net-_D32-Pad2_ TACT
SW33 COL3 Net-_D33-Pad2_ TACT
SW34 COL4 Net-_D34-Pad2_ TACT
SW35 COL5 Net-_D35-Pad2_ TACT
SW36 COL6 Net-_D36-Pad2_ TACT
SW37 COL7 Net-_D37-Pad2_ TACT
SW27 COL7 Net-_D27-Pad2_ TACT
SW17 COL7 Net-_D17-Pad2_ TACT
SW07 COL7 Net-_D07-Pad2_ TACT
SW08 COL8 Net-_D08-Pad2_ TACT
SW28 COL8 Net-_D28-Pad2_ TACT
SW38 COL8 Net-_D38-Pad2_ TACT
SW39 COL9 Net-_D39-Pad2_ TACT
SW29 COL9 Net-_D29-Pad2_ TACT
SW19 COL9 Net-_D19-Pad2_ TACT
SW110 COL10 Net-_D110-Pad2_ TACT
SW210 COL10 Net-_D210-Pad2_ TACT
SW211 COL11 Net-_D211-Pad2_ TACT
SW111 COL11 Net-_D111-Pad2_ TACT
SW09 COL9 Net-_D09-Pad2_ TACT
SWE20 Net-_DE21-Pad1_ ENC2 Net-_DE20-Pad1_ Net-_D40-Pad2_ COL0 Encoder
SWE22 Net-_DE23-Pad1_ ENC2 Net-_DE22-Pad1_ Net-_D41-Pad2_ COL1 Encoder
DE01 Net-_DE01-Pad1_ COL1 D_Small
DE00 Net-_DE00-Pad1_ COL0 D_Small
DE03 Net-_DE03-Pad1_ COL3 D_Small
DE02 Net-_DE02-Pad1_ COL2 D_Small
DE05 Net-_DE05-Pad1_ COL5 D_Small
DE04 Net-_DE04-Pad1_ COL4 D_Small
DE07 Net-_DE07-Pad1_ COL7 D_Small
DE06 Net-_DE06-Pad1_ COL6 D_Small
DE09 Net-_DE09-Pad1_ COL9 D_Small
DE08 Net-_DE08-Pad1_ COL8 D_Small
DE011 Net-_DE011-Pad1_ COL11 D_Small
DE010 Net-_DE010-Pad1_ COL10 D_Small
DE013 Net-_DE013-Pad1_ COL13 D_Small
DE012 Net-_DE012-Pad1_ COL12 D_Small
DE015 Net-_DE015-Pad1_ COL15 D_Small
DE014 Net-_DE014-Pad1_ COL14 D_Small
DE11 Net-_DE11-Pad1_ COL1 D_Small
DE10 Net-_DE10-Pad1_ COL0 D_Small
DE13 Net-_DE13-Pad1_ COL3 D_Small
DE12 Net-_DE12-Pad1_ COL2 D_Small
DE15 Net-_DE15-Pad1_ COL5 D_Small
DE14 Net-_DE14-Pad1_ COL4 D_Small
DE17 Net-_DE17-Pad1_ COL7 D_Small
DE16 Net-_DE16-Pad1_ COL6 D_Small
DE19 Net-_DE19-Pad1_ COL9 D_Small
DE18 Net-_DE18-Pad1_ COL8 D_Small
DE111 Net-_DE111-Pad1_ COL11 D_Small
DE110 Net-_DE110-Pad1_ COL10 D_Small
DE21 Net-_DE21-Pad1_ COL1 D_Small
DE20 Net-_DE20-Pad1_ COL0 D_Small
DE23 Net-_DE23-Pad1_ COL3 D_Small
DE22 Net-_DE22-Pad1_ COL2 D_Small
DE25 Net-_DE25-Pad1_ COL5 D_Small
DE24 Net-_DE24-Pad1_ COL4 D_Small
DE27 Net-_DE27-Pad1_ COL7 D_Small
DE26 Net-_DE26-Pad1_ COL6 D_Small
DE29 Net-_DE29-Pad1_ COL9 D_Small
DE28 Net-_DE28-Pad1_ COL8 D_Small
DE211 Net-_DE211-Pad1_ COL11 D_Small
DE210 Net-_DE210-Pad1_ COL10 D_Small
DE213 Net-_DE213-Pad1_ COL13 D_Small
DE212 Net-_DE212-Pad1_ COL12 D_Small
DE215 Net-_DE215-Pad1_ COL15 D_Small
DE214 Net-_DE214-Pad1_ COL14 D_Small
.end
