.title KiCad schematic
RP1 Net-_RP1-Pad1_ Net-_RP1-Pad2_ Net-_RP1-Pad3_ Net-_RP1-Pad4_ Net-_RP1-Pad5_ Net-_RP1-Pad6_ Net-_RP1-Pad7_ Net-_RP1-Pad8_ /RASB2.F* /RASA2.F* /RASB1.F* /RASA1.F* /CASLL.F* /CASLM.F* /CASUM.F* /CASUU.F* 22
SIM1 +5V /CASLL.F* /D_0_ /RABF*_0_ /RABF*_1_ /D_1_ /RABF*_2_ /RABF*_3_ GND /D_2_ /RABF*_4_ /RABF*_5_ /D_3_ /RABF*_6_ /RABF*_7_ /D_4_ /RABF*_8_ /RABF*_9_ /RABF*_10_ /D_5_ /RAMRWBF GND /D_6_ /RABF*_11_ /D_7_ NC_01 /RASB1.F* PU NC_02 +5V +5V /CASLM.F* /D_8_ /RABF*_0_ /RABF*_1_ /D_9_ /RABF*_2_ /RABF*_3_ GND /D_10_ /RABF*_4_ /RABF*_5_ /D_11_ /RABF*_6_ /RABF*_7_ /D_12_ /RABF*_8_ /RABF*_9_ /RABF*_10_ /D_13_ /RAMRWBF GND /D_14_ /RABF*_11_ /D_15_ NC_03 /RASB1.F* PU NC_04 +5V SIM
SIM2 +5V /CASUM.F* /D_16_ /RABF*_0_ /RABF*_1_ /D_17_ /RABF*_2_ /RABF*_3_ GND /D_18_ /RABF*_4_ /RABF*_5_ /D_19_ /RABF*_6_ /RABF*_7_ /D_20_ /RABF*_8_ /RABF*_9_ /RABF*_10_ /D_21_ /RAMRWBF GND /D_22_ /RABF*_11_ /D_23_ NC_05 /RASB2.F* PU NC_06 +5V +5V /CASUU.F* /D_24_ /RABF*_0_ /RABF*_1_ /D_25_ /RABF*_2_ /RABF*_3_ GND /D_26_ /RABF*_4_ /RABF*_5_ /D_27_ /RABF*_6_ /RABF*_7_ /D_28_ /RABF*_8_ /RABF*_9_ /RABF*_10_ /D_29_ /RAMRWBF GND /D_30_ /RABF*_11_ /D_31_ NC_07 /RASB2.F* PU NC_08 +5V SIM
UD1 GND RASA Net-_RP1-Pad1_ RASA Net-_RP1-Pad2_ RASB Net-_RP1-Pad3_ RASB Net-_RP1-Pad4_ CASLL Net-_RP1-Pad8_ CASLM Net-_RP1-Pad6_ CASUM Net-_RP1-Pad7_ CASUU Net-_RP1-Pad5_ GND 74F240
SIM3 +5V /CASLL.F* /D_0_ /RAAF*_0_ /RAAF*_1_ /D_1_ /RAAF*_2_ /RAAF*_3_ GND /D_2_ /RAAF*_4_ /RAAF*_5_ /D_3_ /RAAF*_6_ /RAAF*_7_ /D_4_ /RAAF*_8_ /RAAF*_9_ /RAAF*_10_ /D_5_ /RAMRWAF GND /D_6_ /RAAF*_11_ /D_7_ NC_09 /RASA1.F* PU NC_10 +5V +5V /CASLM.F* /D_8_ /RAAF*_0_ /RAAF*_1_ /D_9_ /RAAF*_2_ /RAAF*_3_ GND /D_10_ /RAAF*_4_ /RAAF*_5_ /D_11_ /RAAF*_6_ /RAAF*_7_ /D_12_ /RAAF*_8_ /RAAF*_9_ /RAAF*_10_ /D_13_ /RAMRWAF GND /D_14_ /RAAF*_11_ /D_15_ NC_11 /RASA1.F* PU NC_12 +5V SIM
SIM4 +5V /CASUM.F* /D_16_ /RAAF*_0_ /RAAF*_1_ /D_17_ /RAAF*_2_ /RAAF*_3_ GND /D_18_ /RAAF*_4_ /RAAF*_5_ /D_19_ /RAAF*_6_ /RAAF*_7_ /D_20_ /RAAF*_8_ /RAAF*_9_ /RAAF*_10_ /D_21_ /RAMRWAF GND /D_22_ /RAAF*_11_ /D_23_ NC_13 /RASA2.F* PU NC_14 NC_15 +5V /CASUU.F* /D_24_ /RAAF*_0_ /RAAF*_1_ /D_25_ /RAAF*_2_ /RAAF*_3_ GND /D_26_ /RAAF*_4_ /RAAF*_5_ /D_27_ /RAAF*_6_ /RAAF*_7_ /D_28_ /RAAF*_8_ /RAAF*_9_ /RAAF*_10_ /D_29_ /RAMRWAF GND /D_30_ /RAAF*_11_ /D_31_ NC_16 /RASA2.F* PU NC_17 NC_18 SIM
S2 NMI* NMI* GND GND NMI (Normally Open)
R25 /RAMRWBF NC_19 22
R26 /RAMRWAF NC_20 22
UI8 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NMI* NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 /A_16_ NC_50 NC_51 NC_52 NC_53 NC_54 /A_13_ NC_55 NC_56 /A_16_ NC_57 NC_58 /A_13_ NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 RASA RASB CASLL CASLM CASUM CASUU GLUE
.end
