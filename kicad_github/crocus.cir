.title KiCad schematic
J2 NC_01 NC_02 NC_03 /INT NC_04 NC_05 NC_06 NC_07 /CE_ALT1 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 /CE_ALT2 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 /MOSI_ALT1 NC_27 /SCK_ALT1 NC_28 /INT_ALT1 NC_29 NC_30 NC_31 /MISO_ALT1 /I2C0_SDA /I2C0_SCL NEIGHBOR2
J1 GND VCC NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 /CSN_ALT2 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 /INT_ALT2 /CSN_ALT1 /SCK /MOSI /MISO NEIGHBOR1
J7 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 NC_82 NC_83 BONUS_ROW
MH3 GND MOUNTING_HOLE
MH4 GND MOUNTING_HOLE
MH1 GND MOUNTING_HOLE
MH2 GND MOUNTING_HOLE
U1 /CE /CSN /SCK /MOSI /MISO /IRQ VCC GND /XC2 /XC1 /VDD_PA /ANT1 /ANT2 GND VCC /IREF GND VCC /DVDD GND nRF24L01+
P1 /RF GND RP-SMA
Y1 /XC2 /XC1 XTAL
C4 /XC2 GND 18pF
C5 /XC1 GND 18pF
R1 GND /IREF 22.0k
T1 /RF GND /ANT2 /ANT1 /VDD_PA BALUN
C3 /VDD_PA GND 2.2nF
C2 /DVDD GND 33nF
C6 VCC GND 10nF
C7 VCC GND 1nF
U2 /AD0 /AD1 /AD2 /P0 /P1 /P2 /P3 GND /P4 /IRQ /CSN /CE /INT /I2C0_SCL /I2C0_SDA VCC PCA9674
R2 VCC /INT 10k
P2 GND VCC GND /P0 GND /P1 GND /P2 GND /P3 GND /P4 EXPANSION
C1 VCC GND 33nF
R4 /AD1 GND 10k
R3 /AD2 GND 10k
R5 /AD0 GND 10k
W15 /SCK_ALT1 /SCK TEST
W18 /MOSI_ALT1 /MOSI TEST
W21 /MISO_ALT1 /MISO TEST
W23 /CSN_ALT2 /CSN TEST
W20 /CSN_ALT1 /CSN TEST
W17 /CE_ALT2 /CE TEST
W14 /CE_ALT1 /CE TEST
W13 /INT_ALT1 /INT TEST
W16 /INT_ALT2 /INT TEST
W19 /INT /IRQ TEST
W22 /INT_ALT1 /IRQ TEST
W24 /INT_ALT2 /IRQ TEST
W1 VCC /AD2 TEST
W4 /I2C0_SDA /AD2 TEST
W7 /I2C0_SCL /AD2 TEST
W10 GND /AD2 TEST
W2 VCC /AD1 TEST
W5 /I2C0_SDA /AD1 TEST
W8 /I2C0_SCL /AD1 TEST
W11 GND /AD1 TEST
W3 VCC /AD0 TEST
W6 /I2C0_SDA /AD0 TEST
W9 /I2C0_SCL /AD0 TEST
W12 GND /AD0 TEST
.end
