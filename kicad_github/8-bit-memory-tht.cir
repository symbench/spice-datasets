.title KiCad schematic
Q1 GND /I0 Net-_Q1-Pad3_ 2N7000
Q2 GND Net-_Q1-Pad3_ Net-_Q2-Pad3_ 2N7000
Q3 GND /notW Net-_Q2-Pad3_ 2N7000
Q6 GND /I0 Net-_Q6-Pad3_ 2N7000
Q7 GND /notW Net-_Q6-Pad3_ 2N7000
Q8 GND Net-_Q6-Pad3_ /FB0 2N7000
Q9 GND Net-_Q4-Pad3_ /FB0 2N7000
Q4 GND Net-_Q2-Pad3_ Net-_Q4-Pad3_ 2N7000
Q5 GND /FB0 Net-_Q4-Pad3_ 2N7000
R2 VCC Net-_Q1-Pad3_ R
R3 VCC Net-_Q2-Pad3_ R
R4 VCC Net-_Q4-Pad3_ R
R5 VCC Net-_Q6-Pad3_ R
R6 VCC /FB0 R
J2 /I0 /I1 /I2 /I3 /I4 /I5 /I6 /I7 J8-8_bit_bus_connector
J1 /W J1-1_bit_bus
Q89 GND /W /notW 2N7000
R65 VCC /notW R
J3 /O0 /O1 /O2 /O3 /O4 /O5 /O6 /O7 J8-8_bit_bus_connector
Q12 GND /I1 Net-_Q12-Pad3_ 2N7000
Q13 GND Net-_Q12-Pad3_ Net-_Q13-Pad3_ 2N7000
Q14 GND /notW Net-_Q13-Pad3_ 2N7000
Q17 GND /I1 Net-_Q17-Pad3_ 2N7000
Q18 GND /notW Net-_Q17-Pad3_ 2N7000
Q19 GND Net-_Q17-Pad3_ /FB1 2N7000
Q20 GND Net-_Q15-Pad3_ /FB1 2N7000
Q15 GND Net-_Q13-Pad3_ Net-_Q15-Pad3_ 2N7000
Q16 GND /FB1 Net-_Q15-Pad3_ 2N7000
R10 VCC Net-_Q12-Pad3_ R
R11 VCC Net-_Q13-Pad3_ R
R12 VCC Net-_Q15-Pad3_ R
R13 VCC Net-_Q17-Pad3_ R
R14 VCC /FB1 R
Q23 GND /I2 Net-_Q23-Pad3_ 2N7000
Q24 GND Net-_Q23-Pad3_ Net-_Q24-Pad3_ 2N7000
Q25 GND /notW Net-_Q24-Pad3_ 2N7000
Q28 GND /I2 Net-_Q28-Pad3_ 2N7000
Q29 GND /notW Net-_Q28-Pad3_ 2N7000
Q30 GND Net-_Q28-Pad3_ /FB2 2N7000
Q31 GND Net-_Q26-Pad3_ /FB2 2N7000
Q26 GND Net-_Q24-Pad3_ Net-_Q26-Pad3_ 2N7000
Q27 GND /FB2 Net-_Q26-Pad3_ 2N7000
R18 VCC Net-_Q23-Pad3_ R
R19 VCC Net-_Q24-Pad3_ R
R20 VCC Net-_Q26-Pad3_ R
R21 VCC Net-_Q28-Pad3_ R
R22 VCC /FB2 R
Q34 GND /I3 Net-_Q34-Pad3_ 2N7000
Q35 GND Net-_Q34-Pad3_ Net-_Q35-Pad3_ 2N7000
Q36 GND /notW Net-_Q35-Pad3_ 2N7000
Q39 GND /I3 Net-_Q39-Pad3_ 2N7000
Q40 GND /notW Net-_Q39-Pad3_ 2N7000
Q41 GND Net-_Q39-Pad3_ /FB3 2N7000
Q42 GND Net-_Q37-Pad3_ /FB3 2N7000
Q37 GND Net-_Q35-Pad3_ Net-_Q37-Pad3_ 2N7000
Q38 GND /FB3 Net-_Q37-Pad3_ 2N7000
R26 VCC Net-_Q34-Pad3_ R
R27 VCC Net-_Q35-Pad3_ R
R28 VCC Net-_Q37-Pad3_ R
R29 VCC Net-_Q39-Pad3_ R
R30 VCC /FB3 R
Q45 GND /I4 Net-_Q45-Pad3_ 2N7000
Q46 GND Net-_Q45-Pad3_ Net-_Q46-Pad3_ 2N7000
Q47 GND /notW Net-_Q46-Pad3_ 2N7000
Q50 GND /I4 Net-_Q50-Pad3_ 2N7000
Q51 GND /notW Net-_Q50-Pad3_ 2N7000
Q52 GND Net-_Q50-Pad3_ /FB4 2N7000
Q53 GND Net-_Q48-Pad3_ /FB4 2N7000
Q48 GND Net-_Q46-Pad3_ Net-_Q48-Pad3_ 2N7000
Q49 GND /FB4 Net-_Q48-Pad3_ 2N7000
R34 VCC Net-_Q45-Pad3_ R
R35 VCC Net-_Q46-Pad3_ R
R36 VCC Net-_Q48-Pad3_ R
R37 VCC Net-_Q50-Pad3_ R
R38 VCC /FB4 R
Q56 GND /I5 Net-_Q56-Pad3_ 2N7000
Q57 GND Net-_Q56-Pad3_ Net-_Q57-Pad3_ 2N7000
Q58 GND /notW Net-_Q57-Pad3_ 2N7000
Q61 GND /I5 Net-_Q61-Pad3_ 2N7000
Q62 GND /notW Net-_Q61-Pad3_ 2N7000
Q63 GND Net-_Q61-Pad3_ /FB5 2N7000
Q64 GND Net-_Q59-Pad3_ /FB5 2N7000
Q59 GND Net-_Q57-Pad3_ Net-_Q59-Pad3_ 2N7000
Q60 GND /FB5 Net-_Q59-Pad3_ 2N7000
R42 VCC Net-_Q56-Pad3_ R
R43 VCC Net-_Q57-Pad3_ R
R44 VCC Net-_Q59-Pad3_ R
R45 VCC Net-_Q61-Pad3_ R
R46 VCC /FB5 R
Q67 GND /I6 Net-_Q67-Pad3_ 2N7000
Q68 GND Net-_Q67-Pad3_ Net-_Q68-Pad3_ 2N7000
Q69 GND /notW Net-_Q68-Pad3_ 2N7000
Q72 GND /I6 Net-_Q72-Pad3_ 2N7000
Q73 GND /notW Net-_Q72-Pad3_ 2N7000
Q74 GND Net-_Q72-Pad3_ /FB6 2N7000
Q75 GND Net-_Q70-Pad3_ /FB6 2N7000
Q70 GND Net-_Q68-Pad3_ Net-_Q70-Pad3_ 2N7000
Q71 GND /FB6 Net-_Q70-Pad3_ 2N7000
R50 VCC Net-_Q67-Pad3_ R
R51 VCC Net-_Q68-Pad3_ R
R52 VCC Net-_Q70-Pad3_ R
R53 VCC Net-_Q72-Pad3_ R
R54 VCC /FB6 R
Q78 GND /I7 Net-_Q78-Pad3_ 2N7000
Q79 GND Net-_Q78-Pad3_ Net-_Q79-Pad3_ 2N7000
Q80 GND /notW Net-_Q79-Pad3_ 2N7000
Q83 GND /I7 Net-_Q83-Pad3_ 2N7000
Q84 GND /notW Net-_Q83-Pad3_ 2N7000
Q85 GND Net-_Q83-Pad3_ /FB7 2N7000
Q86 GND Net-_Q81-Pad3_ /FB7 2N7000
Q81 GND Net-_Q79-Pad3_ Net-_Q81-Pad3_ 2N7000
Q82 GND /FB7 Net-_Q81-Pad3_ 2N7000
R58 VCC Net-_Q78-Pad3_ R
R59 VCC Net-_Q79-Pad3_ R
R60 VCC Net-_Q81-Pad3_ R
R61 VCC Net-_Q83-Pad3_ R
R62 VCC /FB7 R
R1 GND /I0 R
R9 GND /I1 R
R17 GND /I2 R
R25 GND /I3 R
R33 GND /I4 R
R41 GND /I5 R
R49 GND /I6 R
R57 GND /I7 R
Q10 GND /FB0 Net-_Q10-Pad3_ 2N7000
Q11 GND Net-_Q10-Pad3_ /O0 2N7000
R7 VCC Net-_Q10-Pad3_ R
R8 VCC /O0 R
Q21 GND /FB1 Net-_Q21-Pad3_ 2N7000
Q22 GND Net-_Q21-Pad3_ /O1 2N7000
R15 VCC Net-_Q21-Pad3_ R
R16 VCC /O1 R
Q32 GND /FB2 Net-_Q32-Pad3_ 2N7000
Q33 GND Net-_Q32-Pad3_ /O2 2N7000
R23 VCC Net-_Q32-Pad3_ R
R24 VCC /O2 R
Q43 GND /FB3 Net-_Q43-Pad3_ 2N7000
Q44 GND Net-_Q43-Pad3_ /O3 2N7000
R31 VCC Net-_Q43-Pad3_ R
R32 VCC /O3 R
Q54 GND /FB4 Net-_Q54-Pad3_ 2N7000
Q55 GND Net-_Q54-Pad3_ /O4 2N7000
R39 VCC Net-_Q54-Pad3_ R
R40 VCC /O4 R
Q65 GND /FB5 Net-_Q65-Pad3_ 2N7000
Q66 GND Net-_Q65-Pad3_ /O5 2N7000
R47 VCC Net-_Q65-Pad3_ R
R48 VCC /O5 R
Q76 GND /FB6 Net-_Q76-Pad3_ 2N7000
Q77 GND Net-_Q76-Pad3_ /O6 2N7000
R55 VCC Net-_Q76-Pad3_ R
R56 VCC /O6 R
Q87 GND /FB7 Net-_Q87-Pad3_ 2N7000
Q88 GND Net-_Q87-Pad3_ /O7 2N7000
R63 VCC Net-_Q87-Pad3_ R
R64 VCC /O7 R
Q91 GND /I0 Net-_Q91-Pad3_ 2N7000
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ LED
R66 Net-_Q91-Pad3_ Net-_D1-Pad1_ R
Q92 GND /I1 Net-_Q92-Pad3_ 2N7000
D2 Net-_D2-Pad1_ Net-_D1-Pad2_ LED
R67 Net-_Q92-Pad3_ Net-_D2-Pad1_ R
Q93 GND /I2 Net-_Q93-Pad3_ 2N7000
D3 Net-_D3-Pad1_ Net-_D1-Pad2_ LED
R68 Net-_Q93-Pad3_ Net-_D3-Pad1_ R
Q94 GND /I3 Net-_Q94-Pad3_ 2N7000
D4 Net-_D4-Pad1_ Net-_D1-Pad2_ LED
R69 Net-_Q94-Pad3_ Net-_D4-Pad1_ R
Q95 GND /I4 Net-_Q95-Pad3_ 2N7000
D5 Net-_D5-Pad1_ Net-_D1-Pad2_ LED
R70 Net-_Q95-Pad3_ Net-_D5-Pad1_ R
Q96 GND /I5 Net-_Q96-Pad3_ 2N7000
D6 Net-_D6-Pad1_ Net-_D1-Pad2_ LED
R71 Net-_Q96-Pad3_ Net-_D6-Pad1_ R
Q97 GND /I6 Net-_Q97-Pad3_ 2N7000
D7 Net-_D7-Pad1_ Net-_D1-Pad2_ LED
R72 Net-_Q97-Pad3_ Net-_D7-Pad1_ R
Q98 GND /I7 Net-_Q98-Pad3_ 2N7000
D8 Net-_D8-Pad1_ Net-_D1-Pad2_ LED
R73 Net-_Q98-Pad3_ Net-_D8-Pad1_ R
Q99 GND /O0 Net-_Q99-Pad3_ 2N7000
D9 Net-_D9-Pad1_ Net-_D1-Pad2_ LED
R74 Net-_Q99-Pad3_ Net-_D9-Pad1_ R
Q100 GND /O1 Net-_Q100-Pad3_ 2N7000
D10 Net-_D10-Pad1_ Net-_D1-Pad2_ LED
R75 Net-_Q100-Pad3_ Net-_D10-Pad1_ R
Q101 GND /O2 Net-_Q101-Pad3_ 2N7000
D11 Net-_D11-Pad1_ Net-_D1-Pad2_ LED
R76 Net-_Q101-Pad3_ Net-_D11-Pad1_ R
Q102 GND /O3 Net-_Q102-Pad3_ 2N7000
D12 Net-_D12-Pad1_ Net-_D1-Pad2_ LED
R77 Net-_Q102-Pad3_ Net-_D12-Pad1_ R
Q103 GND /O4 Net-_Q103-Pad3_ 2N7000
D13 Net-_D13-Pad1_ Net-_D1-Pad2_ LED
R78 Net-_Q103-Pad3_ Net-_D13-Pad1_ R
Q104 GND /O5 Net-_Q104-Pad3_ 2N7000
D14 Net-_D14-Pad1_ Net-_D1-Pad2_ LED
R79 Net-_Q104-Pad3_ Net-_D14-Pad1_ R
Q105 GND /O6 Net-_Q105-Pad3_ 2N7000
D15 Net-_D15-Pad1_ Net-_D1-Pad2_ LED
R80 Net-_Q105-Pad3_ Net-_D15-Pad1_ R
Q106 GND /O7 Net-_Q106-Pad3_ 2N7000
D16 Net-_D16-Pad1_ Net-_D1-Pad2_ LED
R81 Net-_Q106-Pad3_ Net-_D16-Pad1_ R
J4 GND VCC PWR-2_pole_power_connector
JP2 VCC Net-_D1-Pad2_ SolderJumper_2_Bridged
JP1 VCC Net-_D1-Pad2_ Jumper_2_Open
Q90 GND /W Net-_Q90-Pad3_ 2N7000
D17 Net-_D17-Pad1_ Net-_D1-Pad2_ LED
R82 Net-_Q90-Pad3_ Net-_D17-Pad1_ R
.end
