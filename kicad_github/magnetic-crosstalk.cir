.title KiCad schematic
L1 Net-_L1-Pad1_ /AGG_D_P /AGG_D_N Net-_L1-Pad4_ /AGG_C_N /AGG_C_P Net-_L1-Pad7_ /AGG_B_N /AGG_B_P Net-_L1-Pad10_ /AGG_A_N /AGG_A_P Net-_L1-Pad13_ Net-_L1-Pad14_ Net-_C11-Pad2_ Net-_L1-Pad13_ Net-_L1-Pad14_ Net-_C10-Pad2_ Net-_L1-Pad19_ Net-_L1-Pad20_ Net-_C9-Pad2_ Net-_L1-Pad22_ Net-_L1-Pad23_ Net-_C12-Pad2_ BOURNS_PT6120EL
J1 /AGG_A_P /AGG_A_N /AGG_B_P /AGG_C_P /AGG_C_N /AGG_B_N /AGG_D_P /AGG_D_N NC_01 NC_02 NC_03 NC_04 /VIC_A_P /VIC_A_N /VIC_B_P /VIC_C_P /VIC_C_N /VIC_B_N /VIC_D_P /VIC_D_N NC_05 NC_06 NC_07 NC_08 /A2_A_P /A2_A_N /A2_B_P /A2_C_P /A2_C_N /A2_B_N /A2_D_P /A2_D_N NC_09 NC_10 NC_11 NC_12 /A1X_A_P /A1X_A_N /A1X_B_P /A1X_C_P /A1X_C_N /A1X_B_N /A1X_D_P /A1X_D_N NC_13 NC_14 NC_15 NC_16 /A1_A_P /A1_A_N /A1_B_P /A1_C_P /A1_C_N /A1_B_N /A1_D_P /A1_D_N NC_17 NC_18 NC_19 NC_20 /A2X_A_P /A2X_A_N /A2X_B_P /A2X_C_P /A2X_C_N /A2X_B_N /A2X_D_P /A2X_D_N NC_21 NC_22 NC_23 NC_24 /SHLD STEWART_SS_74500_024
C2 /SHLD /GND 4.7 uF
C3 /SHLD /GND 4.7 uF
R1 Net-_L1-Pad19_ Net-_L1-Pad20_ 100
R2 Net-_L1-Pad22_ Net-_L1-Pad23_ 100
L2 Net-_L2-Pad1_ /VIC_D_P /VIC_D_N Net-_L2-Pad4_ /VIC_C_N /VIC_C_P Net-_L2-Pad7_ /VIC_B_N /VIC_B_P Net-_L2-Pad10_ /VIC_A_N /VIC_A_P /A_P /A_N Net-_C6-Pad2_ /B_P /B_N Net-_C5-Pad2_ /C_P /C_N Net-_C4-Pad2_ /D_N /D_P Net-_C7-Pad2_ BOURNS_PT6120EL
R3 Net-_C1-Pad2_ Net-_L1-Pad1_ 75
R4 Net-_C1-Pad2_ Net-_L1-Pad10_ 75
R5 Net-_C1-Pad2_ Net-_L1-Pad7_ 75
R6 Net-_C1-Pad2_ Net-_L1-Pad4_ 75
C1 /SHLD Net-_C1-Pad2_ 0.01 uF
R11 Net-_C8-Pad2_ Net-_L2-Pad1_ 75
R12 Net-_C8-Pad2_ Net-_L2-Pad10_ 75
R13 Net-_C8-Pad2_ Net-_L2-Pad7_ 75
R14 Net-_C8-Pad2_ Net-_L2-Pad4_ 75
C8 /SHLD Net-_C8-Pad2_ 0.01 uF
C7 /GND Net-_C7-Pad2_ 0.1 uF
C6 /GND Net-_C6-Pad2_ 0.1 uF
C5 /GND Net-_C5-Pad2_ 0.1 uF
C4 /GND Net-_C4-Pad2_ 0.1 uF
R7 /A_N /A_P 100
R8 /B_N /B_P 100
R9 /C_N /C_P 100
R10 /D_P /D_N 100
J2 Net-_J2-Pad1_ /GND SMA
J3 Net-_J3-Pad1_ /GND SMA
J4 Net-_J4-Pad1_ /GND SMA
J5 Net-_J5-Pad1_ /GND SMA
J6 Net-_J6-Pad1_ /GND SMA
J7 Net-_J7-Pad1_ /GND SMA
J8 Net-_J8-Pad1_ /GND SMA
J9 Net-_J9-Pad1_ /GND SMA
C12 /GND Net-_C12-Pad2_ 0.1 uF
C11 /GND Net-_C11-Pad2_ 0.1 uF
C10 /GND Net-_C10-Pad2_ 0.1 uF
C9 /GND Net-_C9-Pad2_ 0.1 uF
MH3 NC_25 Conn_01x01
MH4 NC_26 Conn_01x01
MH1 NC_27 Conn_01x01
MH2 NC_28 Conn_01x01
R15 /A_P Net-_J2-Pad1_ 953
R16 /A_N Net-_J3-Pad1_ 953
R17 /B_P Net-_J4-Pad1_ 953
R18 /B_N Net-_J5-Pad1_ 953
R19 /C_P Net-_J6-Pad1_ 953
R20 /C_N Net-_J7-Pad1_ 953
R21 /D_P Net-_J8-Pad1_ 953
R22 /D_N Net-_J9-Pad1_ 953
R23 /A1Y_A_P /A1_A_P 34.8
R24 /A1Y_A_N /A1_A_N 34.8
R25 /A1Y_B_P /A1_B_P 34.8
R26 /A1Y_B_N /A1_B_N 34.8
R27 /A1Y_D_N /A1_D_N 34.8
R28 /A1Y_D_P /A1_D_P 34.8
R29 /A1Y_C_P /A1_C_P 34.8
R30 /A1Y_C_N /A1_C_N 34.8
R47 /A1X_A_P /A1Y_A_P 34.8
R48 /A1X_A_N /A1Y_A_N 34.8
R49 /A1X_B_P /A1Y_B_P 34.8
R50 /A1X_B_N /A1Y_B_N 34.8
R51 /A1X_D_N /A1Y_D_N 34.8
R52 /A1X_D_P /A1Y_D_P 34.8
R53 /A1X_C_P /A1Y_C_P 34.8
R54 /A1X_C_N /A1Y_C_N 34.8
R39 /A1Y_A_N /A1Y_A_P 36.5
R40 /A1Y_B_N /A1Y_B_P 36.5
R41 /A1Y_D_P /A1Y_D_N 36.5
R42 /A1Y_C_N /A1Y_C_P 36.5
R31 /A2Y_A_N /A2_A_N 34.8
R32 /A2Y_A_P /A2_A_P 34.8
R33 /A2Y_B_N /A2_B_N 34.8
R34 /A2Y_B_P /A2_B_P 34.8
R35 /A2Y_D_P /A2_D_P 34.8
R36 /A2Y_D_N /A2_D_N 34.8
R37 /A2Y_C_P /A2_C_P 34.8
R38 /A2Y_C_N /A2_C_N 34.8
R55 /A2X_A_N /A2Y_A_N 34.8
R56 /A2X_A_P /A2Y_A_P 34.8
R57 /A2X_B_N /A2Y_B_N 34.8
R58 /A2X_B_P /A2Y_B_P 34.8
R59 /A2X_D_P /A2Y_D_P 34.8
R60 /A2X_D_N /A2Y_D_N 34.8
R61 /A2X_C_P /A2Y_C_P 34.8
R62 /A2X_C_N /A2Y_C_N 34.8
R43 /A2Y_A_P /A2Y_A_N 36.5
R44 /A2Y_B_P /A2Y_B_N 36.5
R45 /A2Y_D_N /A2Y_D_P 36.5
R46 /A2Y_C_N /A2Y_C_P 36.5
.end
