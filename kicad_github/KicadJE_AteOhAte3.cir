.title KiCad schematic
U302 Net-_C310-Pad2_ Net-_C310-Pad1_ Net-_R327-Pad2_ +12V Net-_R341-Pad1_ Net-_R347-Pad2_ Net-_R334-Pad1_ -12V TL072
U301 Net-_C307-Pad2_ Net-_C308-Pad1_ Net-_R324-Pad1_ +12V GND Net-_R311-Pad1_ Net-_R311-Pad2_ -12V TL072
RV302 NC_01 Net-_R311-Pad2_ Net-_R309-Pad1_ 1M Decay
RV301 Net-_D309-Pad1_ Net-_R308-Pad1_ GND 500R Tune
C302 GND -12V 100n
C305 +12V GND 100n
C306 +12V GND 100n
C303 GND -12V 100n
D301 -12V GND 1N1007
D302 GND +12V 1N1007
H301 2,5mm
H302 2,5mm
H304 2,2mm
H303 2,2mm
SW301 NC_02 Net-_C307-Pad1_ Net-_C308-Pad2_ GND Net-_R324-Pad2_ NC_03 Con/Tom
P301 -12V -12V GND GND NC_04 NC_05 GND GND +12V +12V Doepfer_Power_10pin
RV304 GND Net-_R328-Pad2_ Net-_C316-Pad1_ 100k A Reverb
Q303 Net-_Q303-Pad1_ GND Net-_Q303-Pad3_ MMBT2222A
R314 Net-_Q302-Pad3_ InAccent2 4k7
R312 InAccent2 +12V 100k
R345 GND InGate2 100k
C315 InGate2 Net-_C315-Pad2_ 10n
R341 Net-_R341-Pad1_ Net-_C315-Pad2_ 47k
R346 GND Net-_R341-Pad1_ 100k
R347 +12V Net-_R347-Pad2_ 100k
R348 Net-_R347-Pad2_ GND 100k
R315 Net-_Q301-Pad1_ Net-_Q302-Pad3_ 4k7
R313 Net-_Q301-Pad1_ +12V 100k
Q302 Net-_Q302-Pad1_ Net-_Q302-Pad2_ Net-_Q302-Pad3_ MMBT2222A
Q301 Net-_Q301-Pad1_ /PNP_E +12V MMBT2222A
R322 GND /PNP_E 4k7
R329 GND Net-_Q302-Pad2_ 4k7
R321 Net-_Q302-Pad2_ +12V 10k
R320 Net-_Q303-Pad3_ Net-_Q302-Pad1_ 15k
R331 Net-_Q303-Pad1_ GND 10k
R334 Net-_R334-Pad1_ Net-_Q303-Pad1_ 22k
R335 Net-_Q305-Pad1_ Net-_R334-Pad1_ 22k
R340 GND Net-_Q305-Pad1_ 10k
Q305 Net-_Q305-Pad1_ GND Net-_Q305-Pad3_ MMBT2222A
R330 Net-_Q305-Pad3_ /PNP_B 10k
R323 /PNP_B /PNP_E 4k7
Q304 /PNP_B /PNP_E /Coupling MMBT2907A
R332 GND /Coupling 4k7
R333 Net-_D312-Pad2_ /Coupling 4k7
D312 Net-_C317-Pad1_ Net-_D312-Pad2_ 1N4148
C317 Net-_C317-Pad1_ GND 33n
R342 Net-_C317-Pad1_ Net-_C314-Pad2_ 2M2
R343 Net-_C314-Pad2_ Net-_Q306-Pad1_ 33k
Q306 Net-_Q306-Pad1_ GND Net-_C313-Pad2_ MMBT2222A
R336 Net-_C313-Pad2_ +12V 4k7
C313 Net-_C313-Pad1_ Net-_C313-Pad2_ 33n
C312 Net-_C312-Pad1_ /Coupling 2n7
D311 Net-_C312-Pad1_ GND 1N4148
R326 Net-_R324-Pad1_ Net-_C312-Pad1_ 22k
R324 Net-_R324-Pad1_ Net-_R324-Pad2_ 2k5
R325 Net-_R324-Pad1_ GND 6k8
R310 Net-_C307-Pad2_ Net-_C308-Pad1_ 820k
C308 Net-_C308-Pad1_ Net-_C308-Pad2_ 27n
C309 Net-_C308-Pad2_ Net-_C307-Pad2_ 12n
R317 Net-_C307-Pad2_ Net-_R311-Pad1_ 33k
R311 Net-_R311-Pad1_ Net-_R311-Pad2_ 33k
R309 Net-_R309-Pad1_ Net-_C308-Pad2_ 470k
D309 Net-_D309-Pad1_ Net-_C308-Pad2_ 1N4148
D310 Net-_C308-Pad2_ Net-_D309-Pad1_ 1N4148
C307 Net-_C307-Pad1_ Net-_C307-Pad2_ 27n
R308 Net-_R308-Pad1_ Net-_C308-Pad2_ 1k
R318 Net-_R311-Pad2_ Net-_C311-Pad1_ 100k
C311 Net-_C311-Pad1_ Net-_C310-Pad1_ 39n
R327 GND Net-_R327-Pad2_ 4k7
R316 Net-_C310-Pad2_ Net-_C310-Pad1_ 470k
C310 Net-_C310-Pad1_ Net-_C310-Pad2_ 1n
R344 GND Net-_C313-Pad1_ 22k
R339 Net-_C313-Pad1_ Net-_C316-Pad1_ 22k
C316 Net-_C316-Pad1_ GND 15n
R328 Net-_C311-Pad1_ Net-_R328-Pad2_ 100k
R319 Net-_C310-Pad2_ OutTom2 1k
R302 Net-_J302-PadT_ InAccent2 1K
R304 InAccent2 GND OPEN
R305 Net-_J303-PadT_ InGate2 1K
R306 InGate2 GND OPEN
J303 GND Net-_J303-PadT_ GND In Gate
J304 GND Net-_J304-PadT_ Out Tom
J302 GND Net-_J302-PadT_ GND In_Accent
R307 Net-_J304-PadT_ OutTom2 0R
RV303 Net-_C310-Pad1_ Net-_C310-Pad2_ NC_06 100k A Level
C314 Net-_C314-Pad1_ Net-_C314-Pad2_ 47n
R337 GND Net-_C314-Pad1_ 3k3
R338 Net-_C314-Pad1_ NoiseIn2 33k
D313 Net-_C315-Pad2_ GND 1N4148
TP301 /Coupling Coupling
C301 GND -12V 10u
C304 +12V GND 10u
R301 Net-_J301-PadT_ NoiseIn2 1K
R303 NoiseIn2 GND OPEN
D303 NoiseIn2 Net-_D303-Pad2_ Zener
J301 GND Net-_J301-PadT_ GND Noise_In
D306 GND Net-_D303-Pad2_ Zener
D304 InAccent2 Net-_D304-Pad2_ Zener
D307 InGate2 Net-_D307-Pad2_ Zener
D308 GND Net-_D307-Pad2_ Zener
D305 GND Net-_D304-Pad2_ Zener
.end
