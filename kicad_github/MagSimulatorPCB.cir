.title KiCad schematic
U2 GND +3V3 GND +3V3 GND /D20 +3V3 /D23 /D6 /FPGA_RES# /D9 /D10 /D17 /D18 /D1 /D22 /D4 /D25 GND /D8 /D11 GND +3V3 +3V3 /D16 /D0 /D2 /D3 /D24 +3V3 /D12 GND /D19 /D21 GND /D5 /D7 /CS# /D13 +3V3 /D15 /MCU_EMLE GND /D14 /D26 /D27 +3V3 +3V3 GND /D28 /A0 GND Net-_R11-Pad1_ NC_01 /MCU_MD /MCU_TRST# /D29 /D30 /A1 +3V3 NC_02 GND /MCU_RES# GND /A4 /A3 /A2 /D31 /CLK24 +3V3 /MCU_TMS /A5 GND /A7 /A6 /MCU_TDI /MCU_TCK +3V3 /A8 /MCU_TDO /A9 +3V3 +3V3 Net-_R22-Pad1_ +3V3 /WR0# +3V3 /WR3# GND GND GND /WR1# /MCU_UB GND GND GND /USB_DM /RD# +3V3 /WR2# GND /USB_DP +3V3 /BCLK GND +3V3 R5F571MLDDBG_MagSim
U3 GND /LED_B /LED_G /LED_R /A8 /A6 /A7 /A2 /A9 /D26 /A0 /D31 GND GND /D28 /D27 /D15 GND Net-_R16-Pad1_ Net-_R18-Pad1_ +3V3 +3V3 +3V3 /FPGA_RES# /D29 /D10 /D11 GND +3V3 +3V3 GND GND +3V3 /D14 /D9 /D8 GND /FPAG_JTAGEN Net-_R15-Pad1_ /A3 GND /D13 /D12 +3V3 GND /FPGA_TDI /FPGA_TDO +3V3 /CS# +3V3 /A1 /D30 /FPGA_TMS /FPGA_TCK +3V3 +3V3 GND +3V3 /A4 +3V3 /D7 /D6 +3V3 /D24 +3V3 GND /D25 +3V3 GND /A5 +3V3 /D4 /D23 +3V3 +3V3 /BCLK +3V3 /D5 /D3 /D20 /D22 +3V3 +3V3 +3V3 GND /D0 /D2 /D18 /D1 GND /D21 /D16 /D17 GND /WR2# /WR3# /RD# /WR1# /WR0# /D19 GND MAX10_16SCU169_MagSim
R15 Net-_R15-Pad1_ +3V3 4.7k
R16 Net-_R16-Pad1_ +3V3 4.7k
R18 Net-_R18-Pad1_ +3V3 4.7k
J3 GND /FPAG_JTAGEN /FPGA_TDI /FPGA_TMS /FPGA_TDO /FPGA_TCK GND FPGA_JTAG
R12 +3V3 /FPGA_TMS 4.7k
R13 +3V3 /FPGA_TDI 4.7k
R14 +3V3 /FPAG_JTAGEN 4.7k
R21 /FPGA_TCK GND 4.7k
J2 GND /MCU_EMLE /MCU_TRST# /MCU_MD /MCU_RES# /MCU_TMS /MCU_TCK /MCU_TDI /MCU_TDO /MCU_UB +3V3 GND MCU_JTAG
R2 +3V3 /MCU_UB 4.7k
R3 +3V3 /MCU_TDO 4.7k
R4 +3V3 /MCU_TDI 4.7k
R5 +3V3 /MCU_TCK 4.7k
R6 +3V3 /MCU_TMS 4.7k
R7 +3V3 /MCU_RES# 4.7k
R8 +3V3 /MCU_MD 4.7k
R9 /MCU_TRST# GND 4.7k
R10 /MCU_EMLE GND 4.7k
R11 Net-_R11-Pad1_ GND 4.7k
J1 Net-_C2-Pad1_ /USB_DM /USB_DP GND GND USB_A
O1 NC_03 GND /CLK24 +3V3 DSC1001CI5-024.0000
U1 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_C3-Pad1_ GND NC_04 NC_05 +3V3 +3V3 GND MCP1725
R1 Net-_C3-Pad1_ Net-_C2-Pad1_ 100k
C3 Net-_C3-Pad1_ GND 4.7u
C2 Net-_C2-Pad1_ GND 4.7u
C1 +3V3 GND 4.7u
C4 +3V3 GND 0.01u
R22 Net-_R22-Pad1_ GND 2.2k
LED1 +3V3 Net-_LED1-Pad2_ Net-_LED1-Pad3_ Net-_LED1-Pad4_ RGB_LED
R17 Net-_LED1-Pad4_ /LED_R 330
R19 Net-_LED1-Pad3_ /LED_G 330
R20 Net-_LED1-Pad2_ /LED_B 330
C5 +3V3 GND 0.01u
C6 +3V3 GND 0.01u
C7 +3V3 GND 0.01u
C8 +3V3 GND 0.01u
C9 +3V3 GND 0.01u
C10 +3V3 GND 0.01u
C11 +3V3 GND 0.01u
C12 +3V3 GND 0.01u
C13 +3V3 GND 0.01u
C14 +3V3 GND 0.01u
C15 +3V3 GND 0.01u
C16 +3V3 GND 0.01u
C17 +3V3 GND 0.01u
C18 +3V3 GND 0.01u
C19 +3V3 GND 0.01u
C20 +3V3 GND 0.01u
C21 +3V3 GND 0.01u
C22 +3V3 GND 0.01u
C23 +3V3 GND 0.01u
C24 +3V3 GND 0.01u
C25 +3V3 GND 0.1u
C26 +3V3 GND 0.1u
C27 +3V3 GND 4.7u
C28 +3V3 GND 4.7u
.end
