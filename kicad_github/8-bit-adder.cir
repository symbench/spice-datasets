.title KiCad schematic
J4 /S0 /S1 /S2 /S3 /S4 /S5 /S6 /S7 J8-8_bit_bus_connector
Q17 GND /a1 Net-_Q17-Pad3_ 2N7000
Q26 Net-_Q25-Pad3_ /b1 Net-_Q26-Pad3_ 2N7000
Q25 GND /a1 Net-_Q25-Pad3_ 2N7000
Q18 GND /b1 Net-_Q17-Pad3_ 2N7000
Q27 GND Net-_Q26-Pad3_ Net-_Q20-Pad2_ 2N7000
R13 VCC Net-_Q17-Pad3_ 1M
R19 VCC Net-_Q26-Pad3_ 1M
R20 VCC Net-_Q20-Pad2_ 1M
Q19 GND Net-_Q17-Pad3_ Net-_Q19-Pad3_ 2N7000
Q20 GND Net-_Q20-Pad2_ Net-_Q19-Pad3_ 2N7000
R14 VCC Net-_Q19-Pad3_ 1M
Q21 GND /C0 Net-_Q21-Pad3_ 2N7000
Q22 GND Net-_Q19-Pad3_ Net-_Q21-Pad3_ 2N7000
R15 VCC Net-_Q21-Pad3_ 1M
Q30 GND Net-_Q29-Pad3_ Net-_Q24-Pad2_ 2N7000
R22 VCC Net-_Q24-Pad2_ 1M
Q23 GND Net-_Q21-Pad3_ /S1 2N7000
Q24 GND Net-_Q24-Pad2_ /S1 2N7000
R16 VCC /S1 1M
Q29 Net-_Q28-Pad3_ Net-_Q19-Pad3_ Net-_Q29-Pad3_ 2N7000
Q28 GND /C0 Net-_Q28-Pad3_ 2N7000
R21 VCC Net-_Q29-Pad3_ 1M
Q32 Net-_Q31-Pad3_ Net-_Q26-Pad3_ /C1 2N7000
Q31 GND Net-_Q29-Pad3_ Net-_Q31-Pad3_ 2N7000
R23 VCC /C1 1M
Q33 GND /a2 Net-_Q33-Pad3_ 2N7000
Q42 Net-_Q41-Pad3_ /b2 Net-_Q42-Pad3_ 2N7000
Q41 GND /a2 Net-_Q41-Pad3_ 2N7000
Q34 GND /b2 Net-_Q33-Pad3_ 2N7000
Q43 GND Net-_Q42-Pad3_ Net-_Q36-Pad2_ 2N7000
R24 VCC Net-_Q33-Pad3_ 1M
R30 VCC Net-_Q42-Pad3_ 1M
R31 VCC Net-_Q36-Pad2_ 1M
Q35 GND Net-_Q33-Pad3_ Net-_Q35-Pad3_ 2N7000
Q36 GND Net-_Q36-Pad2_ Net-_Q35-Pad3_ 2N7000
R25 VCC Net-_Q35-Pad3_ 1M
Q37 GND /C1 Net-_Q37-Pad3_ 2N7000
Q38 GND Net-_Q35-Pad3_ Net-_Q37-Pad3_ 2N7000
R26 VCC Net-_Q37-Pad3_ 1M
Q46 GND Net-_Q45-Pad3_ Net-_Q40-Pad2_ 2N7000
R33 VCC Net-_Q40-Pad2_ 1M
Q39 GND Net-_Q37-Pad3_ /S2 2N7000
Q40 GND Net-_Q40-Pad2_ /S2 2N7000
R27 VCC /S2 1M
Q45 Net-_Q44-Pad3_ Net-_Q35-Pad3_ Net-_Q45-Pad3_ 2N7000
Q44 GND /C1 Net-_Q44-Pad3_ 2N7000
R32 VCC Net-_Q45-Pad3_ 1M
Q48 Net-_Q47-Pad3_ Net-_Q42-Pad3_ /C2 2N7000
Q47 GND Net-_Q45-Pad3_ Net-_Q47-Pad3_ 2N7000
R34 VCC /C2 1M
Q49 GND /a3 Net-_Q49-Pad3_ 2N7000
Q58 Net-_Q57-Pad3_ /b3 Net-_Q58-Pad3_ 2N7000
Q57 GND /a3 Net-_Q57-Pad3_ 2N7000
Q50 GND /b3 Net-_Q49-Pad3_ 2N7000
Q59 GND Net-_Q58-Pad3_ Net-_Q52-Pad2_ 2N7000
R35 VCC Net-_Q49-Pad3_ 1M
R41 VCC Net-_Q58-Pad3_ 1M
R42 VCC Net-_Q52-Pad2_ 1M
Q51 GND Net-_Q49-Pad3_ Net-_Q51-Pad3_ 2N7000
Q52 GND Net-_Q52-Pad2_ Net-_Q51-Pad3_ 2N7000
R36 VCC Net-_Q51-Pad3_ 1M
Q53 GND /C2 Net-_Q53-Pad3_ 2N7000
Q54 GND Net-_Q51-Pad3_ Net-_Q53-Pad3_ 2N7000
R37 VCC Net-_Q53-Pad3_ 1M
Q62 GND Net-_Q61-Pad3_ Net-_Q56-Pad2_ 2N7000
R44 VCC Net-_Q56-Pad2_ 1M
Q55 GND Net-_Q53-Pad3_ /S3 2N7000
Q56 GND Net-_Q56-Pad2_ /S3 2N7000
R38 VCC /S3 1M
Q61 Net-_Q60-Pad3_ Net-_Q51-Pad3_ Net-_Q61-Pad3_ 2N7000
Q60 GND /C2 Net-_Q60-Pad3_ 2N7000
R43 VCC Net-_Q61-Pad3_ 1M
Q64 Net-_Q63-Pad3_ Net-_Q58-Pad3_ /C3 2N7000
Q63 GND Net-_Q61-Pad3_ Net-_Q63-Pad3_ 2N7000
R45 VCC /C3 1M
Q65 GND /a4 Net-_Q65-Pad3_ 2N7000
Q74 Net-_Q73-Pad3_ /b4 Net-_Q74-Pad3_ 2N7000
Q73 GND /a4 Net-_Q73-Pad3_ 2N7000
Q66 GND /b4 Net-_Q65-Pad3_ 2N7000
Q75 GND Net-_Q74-Pad3_ Net-_Q68-Pad2_ 2N7000
R46 VCC Net-_Q65-Pad3_ 1M
R52 VCC Net-_Q74-Pad3_ 1M
R53 VCC Net-_Q68-Pad2_ 1M
Q67 GND Net-_Q65-Pad3_ Net-_Q67-Pad3_ 2N7000
Q68 GND Net-_Q68-Pad2_ Net-_Q67-Pad3_ 2N7000
R47 VCC Net-_Q67-Pad3_ 1M
Q69 GND /C3 Net-_Q69-Pad3_ 2N7000
Q70 GND Net-_Q67-Pad3_ Net-_Q69-Pad3_ 2N7000
R48 VCC Net-_Q69-Pad3_ 1M
Q78 GND Net-_Q77-Pad3_ Net-_Q72-Pad2_ 2N7000
R55 VCC Net-_Q72-Pad2_ 1M
Q71 GND Net-_Q69-Pad3_ /S4 2N7000
Q72 GND Net-_Q72-Pad2_ /S4 2N7000
R49 VCC /S4 1M
Q77 Net-_Q76-Pad3_ Net-_Q67-Pad3_ Net-_Q77-Pad3_ 2N7000
Q76 GND /C3 Net-_Q76-Pad3_ 2N7000
R54 VCC Net-_Q77-Pad3_ 1M
Q80 Net-_Q79-Pad3_ Net-_Q74-Pad3_ /C4 2N7000
Q79 GND Net-_Q77-Pad3_ Net-_Q79-Pad3_ 2N7000
R56 VCC /C4 1M
Q81 GND /a5 Net-_Q81-Pad3_ 2N7000
Q90 Net-_Q89-Pad3_ /b5 Net-_Q90-Pad3_ 2N7000
Q89 GND /a5 Net-_Q89-Pad3_ 2N7000
Q82 GND /b5 Net-_Q81-Pad3_ 2N7000
Q91 GND Net-_Q90-Pad3_ Net-_Q84-Pad2_ 2N7000
R57 VCC Net-_Q81-Pad3_ 1M
R63 VCC Net-_Q90-Pad3_ 1M
R64 VCC Net-_Q84-Pad2_ 1M
Q83 GND Net-_Q81-Pad3_ Net-_Q83-Pad3_ 2N7000
Q84 GND Net-_Q84-Pad2_ Net-_Q83-Pad3_ 2N7000
R58 VCC Net-_Q83-Pad3_ 1M
Q85 GND /C4 Net-_Q85-Pad3_ 2N7000
Q86 GND Net-_Q83-Pad3_ Net-_Q85-Pad3_ 2N7000
R59 VCC Net-_Q85-Pad3_ 1M
Q94 GND Net-_Q93-Pad3_ Net-_Q88-Pad2_ 2N7000
R66 VCC Net-_Q88-Pad2_ 1M
Q87 GND Net-_Q85-Pad3_ /S5 2N7000
Q88 GND Net-_Q88-Pad2_ /S5 2N7000
R60 VCC /S5 1M
Q93 Net-_Q92-Pad3_ Net-_Q83-Pad3_ Net-_Q93-Pad3_ 2N7000
Q92 GND /C4 Net-_Q92-Pad3_ 2N7000
R65 VCC Net-_Q93-Pad3_ 1M
Q96 Net-_Q95-Pad3_ Net-_Q90-Pad3_ /C5 2N7000
Q95 GND Net-_Q93-Pad3_ Net-_Q95-Pad3_ 2N7000
R67 VCC /C5 1M
Q97 GND /a6 Net-_Q97-Pad3_ 2N7000
Q106 Net-_Q105-Pad3_ /b6 Net-_Q106-Pad3_ 2N7000
Q105 GND /a6 Net-_Q105-Pad3_ 2N7000
Q98 GND /b6 Net-_Q97-Pad3_ 2N7000
Q107 GND Net-_Q106-Pad3_ Net-_Q100-Pad2_ 2N7000
R68 VCC Net-_Q97-Pad3_ 1M
R74 VCC Net-_Q106-Pad3_ 1M
R75 VCC Net-_Q100-Pad2_ 1M
Q99 GND Net-_Q97-Pad3_ Net-_Q100-Pad3_ 2N7000
Q100 GND Net-_Q100-Pad2_ Net-_Q100-Pad3_ 2N7000
R69 VCC Net-_Q100-Pad3_ 1M
Q101 GND /C5 Net-_Q101-Pad3_ 2N7000
Q102 GND Net-_Q100-Pad3_ Net-_Q101-Pad3_ 2N7000
R70 VCC Net-_Q101-Pad3_ 1M
Q110 GND Net-_Q109-Pad3_ Net-_Q104-Pad2_ 2N7000
R77 VCC Net-_Q104-Pad2_ 1M
Q103 GND Net-_Q101-Pad3_ /S6 2N7000
Q104 GND Net-_Q104-Pad2_ /S6 2N7000
R71 VCC /S6 1M
Q109 Net-_Q108-Pad3_ Net-_Q100-Pad3_ Net-_Q109-Pad3_ 2N7000
Q108 GND /C5 Net-_Q108-Pad3_ 2N7000
R76 VCC Net-_Q109-Pad3_ 1M
Q112 Net-_Q111-Pad3_ Net-_Q106-Pad3_ /C6 2N7000
Q111 GND Net-_Q109-Pad3_ Net-_Q111-Pad3_ 2N7000
R78 VCC /C6 1M
Q113 GND /a7 Net-_Q113-Pad3_ 2N7000
Q122 Net-_Q121-Pad3_ /b7 Net-_Q122-Pad3_ 2N7000
Q121 GND /a7 Net-_Q121-Pad3_ 2N7000
Q114 GND /b7 Net-_Q113-Pad3_ 2N7000
Q123 GND Net-_Q122-Pad3_ Net-_Q116-Pad2_ 2N7000
R79 VCC Net-_Q113-Pad3_ 1M
R85 VCC Net-_Q122-Pad3_ 1M
R86 VCC Net-_Q116-Pad2_ 1M
Q115 GND Net-_Q113-Pad3_ Net-_Q115-Pad3_ 2N7000
Q116 GND Net-_Q116-Pad2_ Net-_Q115-Pad3_ 2N7000
R80 VCC Net-_Q115-Pad3_ 1M
Q117 GND /C6 Net-_Q117-Pad3_ 2N7000
Q118 GND Net-_Q115-Pad3_ Net-_Q117-Pad3_ 2N7000
R81 VCC Net-_Q117-Pad3_ 1M
Q126 GND Net-_Q125-Pad3_ Net-_Q120-Pad2_ 2N7000
R88 VCC Net-_Q120-Pad2_ 1M
Q119 GND Net-_Q117-Pad3_ /S7 2N7000
Q120 GND Net-_Q120-Pad2_ /S7 2N7000
R82 VCC /S7 1M
Q125 Net-_Q124-Pad3_ Net-_Q115-Pad3_ Net-_Q125-Pad3_ 2N7000
Q124 GND /C6 Net-_Q124-Pad3_ 2N7000
R87 VCC Net-_Q125-Pad3_ 1M
Q128 Net-_Q127-Pad3_ Net-_Q122-Pad3_ /C7 2N7000
Q127 GND Net-_Q125-Pad3_ Net-_Q127-Pad3_ 2N7000
R89 VCC /C7 1M
R17 GND /a1 1M
R18 GND /b1 1M
R28 GND /a2 1M
R29 GND /b2 1M
R39 GND /a3 1M
R40 GND /b3 1M
R50 GND /a4 1M
R51 GND /b4 1M
R61 GND /a5 1M
R62 GND /b5 1M
R72 GND /a6 1M
R73 GND /b6 1M
R83 GND /a7 1M
R84 GND /b7 1M
Q1 GND /a0 Net-_Q1-Pad3_ 2N7000
Q10 Net-_Q10-Pad1_ /b0 Net-_Q10-Pad3_ 2N7000
Q9 GND /a0 Net-_Q10-Pad1_ 2N7000
Q2 GND /b0 Net-_Q1-Pad3_ 2N7000
Q11 GND Net-_Q10-Pad3_ Net-_Q11-Pad3_ 2N7000
R2 VCC Net-_Q1-Pad3_ 1M
R8 VCC Net-_Q10-Pad3_ 1M
R9 VCC Net-_Q11-Pad3_ 1M
Q3 GND Net-_Q1-Pad3_ Net-_Q13-Pad2_ 2N7000
Q4 GND Net-_Q11-Pad3_ Net-_Q13-Pad2_ 2N7000
R3 VCC Net-_Q13-Pad2_ 1M
Q5 GND /c Net-_Q5-Pad3_ 2N7000
Q6 GND Net-_Q13-Pad2_ Net-_Q5-Pad3_ 2N7000
R4 VCC Net-_Q5-Pad3_ 1M
Q14 GND Net-_Q13-Pad3_ Net-_Q14-Pad3_ 2N7000
R11 VCC Net-_Q14-Pad3_ 1M
Q7 GND Net-_Q5-Pad3_ /S0 2N7000
Q8 GND Net-_Q14-Pad3_ /S0 2N7000
R5 VCC /S0 1M
Q13 Net-_Q12-Pad3_ Net-_Q13-Pad2_ Net-_Q13-Pad3_ 2N7000
Q12 GND /c Net-_Q12-Pad3_ 2N7000
R10 VCC Net-_Q13-Pad3_ 1M
Q16 Net-_Q15-Pad3_ Net-_Q10-Pad3_ /C0 2N7000
Q15 GND Net-_Q13-Pad3_ Net-_Q15-Pad3_ 2N7000
R12 VCC /C0 1M
R6 GND /a0 1M
R7 GND /b0 1M
J2 /c J1-1_bit_bus
R1 GND /c 1M
J6 /b0 /b1 /b2 /b3 /b4 /b5 /b6 /b7 J8-8_bit_bus_connector
J3 /a0 /a1 /a2 /a3 /a4 /a5 /a6 /a7 J8-8_bit_bus_connector
Q129 GND /C6 Net-_Q129-Pad3_ 2N7000
Q134 Net-_Q133-Pad3_ /C7 Net-_Q134-Pad3_ 2N7000
Q133 GND /C6 Net-_Q133-Pad3_ 2N7000
Q130 GND /C7 Net-_Q129-Pad3_ 2N7000
Q135 GND Net-_Q134-Pad3_ Net-_Q132-Pad2_ 2N7000
R90 VCC Net-_Q129-Pad3_ 1M
R92 VCC Net-_Q134-Pad3_ 1M
R93 VCC Net-_Q132-Pad2_ 1M
Q131 GND Net-_Q129-Pad3_ /Os 2N7000
Q132 GND Net-_Q132-Pad2_ /Os 2N7000
R91 VCC /Os 1M
J1 GND VCC PWR-2_pole_power_connector
J5 /C7 /Os J2-2_bit_bus
.end
