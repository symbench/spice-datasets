.title KiCad schematic
U3 Net-_R3-Pad2_ GND /ADC/+12V_IN_ADC_OUT /ADC/+12V_IN_ADC_OUT +3V3 LM321
U1 NC_01 GND NC_02 NC_03 +3V3 LM321
C2 +3V3 GND 0.1uf
U2 Net-_R1-Pad2_ GND /ADC/+5V_IN_ADC_OUT /ADC/+5V_IN_ADC_OUT +3V3 LM321
C1 +3V3 GND 0.1uf
U5 Net-_R7-Pad2_ GND /ADC/+12V_BUS_ADC_OUT /ADC/+12V_BUS_ADC_OUT +3V3 LM321
C4 +3V3 GND 0.1uf
U4 Net-_R5-Pad2_ GND /ADC/+5V_BUS_ADC_OUT /ADC/+5V_BUS_ADC_OUT +3V3 LM321
C3 +3V3 GND 0.1uf
R3 +12V_IN Net-_R3-Pad2_ 10K
R4 Net-_R3-Pad2_ GND 3.3K
R7 +12V_BUS Net-_R7-Pad2_ 10K
R8 Net-_R7-Pad2_ GND 3.3K
R5 +5V_BUS Net-_R5-Pad2_ 3K
R6 Net-_R5-Pad2_ GND 4.7K
R1 +5V_IN Net-_R1-Pad2_ 3K
R2 Net-_R1-Pad2_ GND 4.7K
J1 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 Conn_02x05_Top_Bottom
U6 GND +3V3 Net-_C10-Pad1_ LM1117-3.3
C7 +5V_BUS GND 100uF
C8 +5V_BUS GND 100uF
C5 +5V_BUS GND 100uF
C6 +5V_BUS GND 100uF
C11 +3V3 GND 100pF
C12 +3V3 GND 10uF
C13 +3V3 GND 10uF
C10 Net-_C10-Pad1_ GND 25V 10uF
C9 Net-_C10-Pad1_ GND 50V 100pF
J2 GND GND GND GND +12V_BUS +12V_BUS +12V_BUS +5V_BUS +5V_BUS +12V_BUS Conn_02x05_Top_Bottom
J3 GND GND GND GND +12V_BUS +12V_BUS +12V_BUS +5V_BUS +5V_BUS +12V_BUS Conn_02x05_Top_Bottom
J4 GND GND GND GND +12V_BUS +12V_BUS +12V_BUS +5V_BUS +5V_BUS +12V_BUS Conn_02x05_Top_Bottom
J5 GND GND GND GND +12V_BUS +12V_BUS +12V_BUS +5V_BUS +5V_BUS +12V_BUS Conn_02x05_Top_Bottom
C22 +12V_BUS GND 100uF
C26 +12V_BUS GND 100uF
C14 +12V_BUS GND 100uF
C18 +12V_BUS GND 100uF
C15 +12V_BUS GND 100pF
C19 +12V_BUS GND 100pF
C23 +12V_BUS GND 100pF
C27 +12V_BUS GND 100pF
C24 +5V_BUS GND 100uF
C28 +5V_BUS GND 100uF
C16 +5V_BUS GND 100uF
C20 +5V_BUS GND 100uF
C17 +5V_BUS GND 100pF
C21 +5V_BUS GND 100pF
C25 +5V_BUS GND 100pF
C29 +5V_BUS GND 100pF
J6 GND +12V_BUS NC_14 Net-_J6-Pad4_ Conn_01x04
Q1 /Fan Control/PWM_01 GND Net-_J6-Pad4_ 2N7002
R14 /Fan Control/PWM_01 GND 10K
R9 +5V_BUS Net-_J6-Pad4_ 4.7K
J7 GND +12V_BUS NC_15 Net-_J7-Pad4_ Conn_01x04
Q2 /Fan Control/PWM_02 GND Net-_J7-Pad4_ 2N7002
R15 /Fan Control/PWM_02 GND 10K
R10 +5V_BUS Net-_J7-Pad4_ 4.7K
J8 GND +12V_BUS NC_16 Net-_J8-Pad4_ Conn_01x04
Q3 /Fan Control/PWM_03 GND Net-_J8-Pad4_ 2N7002
R16 /Fan Control/PWM_03 GND 10K
R11 +5V_BUS Net-_J8-Pad4_ 4.7K
J9 GND +12V_BUS NC_17 Net-_J9-Pad4_ Conn_01x04
Q4 /Fan Control/PWM_04 GND Net-_J9-Pad4_ 2N7002
R17 /Fan Control/PWM_04 GND 10K
R12 +5V_BUS Net-_J9-Pad4_ 4.7K
J10 GND +12V_BUS NC_18 Net-_J10-Pad4_ Conn_01x04
Q5 /Fan Control/PWM_05 GND Net-_J10-Pad4_ 2N7002
R18 /Fan Control/PWM_05 GND 10K
R13 +5V_BUS Net-_J10-Pad4_ 4.7K
C33 +12V_BUS GND 100uF
C31 +12V_BUS GND 100uF
C32 +5V_BUS GND 100pF
C34 +5V_BUS GND 100uF
C30 +12V_BUS GND 100pF
Q6 /Power OR/CurentSensor5V_Scale_10X GND Net-_Q6-Pad3_ 2N7002
R21 /Power OR/CurentSensor5V_Scale_10X GND 10K
R19 /Power OR/CurentSensor5V Net-_Q6-Pad3_ 10K
U10 Net-_C46-Pad1_ GND /Power OR/Enable_5V Net-_C41-Pad1_ Net-_Q10-Pad4_ +5V_BUS LM5050-1
U9 GND +3V3 Net-_C37-Pad1_ LM1117-3.3
C43 +3V3 GND 100pF
C44 +3V3 GND 10uF
C45 +3V3 GND 10uF
C40 Net-_C37-Pad1_ GND 25V 10uF
C37 Net-_C37-Pad1_ GND 50V 100pF
Q10 Net-_C41-Pad1_ Net-_C41-Pad1_ Net-_C41-Pad1_ Net-_Q10-Pad4_ +5V_BUS PSMN1R8-40YLC
R31 +5V_BUS Net-_C46-Pad1_ 100R
C52 +5V_BUS GND 2.2uF
C46 Net-_C46-Pad1_ GND 100pF
C48 +5V_BUS GND 100pF
C50 +5V_BUS GND 1uF
D3 +5V_BUS GND SMBJxxxAQ
R29 /Power OR/Enable_5V GND 10K
D1 Net-_C41-Pad1_ GND SMBJxxxAQ
U7 /Power OR/CurentSensor5V GND +5V_IN Net-_C41-Pad1_ +3V3 INA139
C41 Net-_C41-Pad1_ GND 1uF
R27 +5V_IN Net-_C41-Pad1_ 0.5mR
C38 +3V3 GND 100pF
C35 +3V3 GND 1uF
Q8 /Power OR/CurentSensor5V_Scale_100X GND Net-_Q8-Pad3_ 2N7002
R25 /Power OR/CurentSensor5V_Scale_100X GND 10K
R23 /Power OR/CurentSensor5V Net-_Q8-Pad3_ 100K
Q12 Net-_C42-Pad1_ Net-_C42-Pad1_ Net-_C42-Pad1_ Net-_Q11-Pad4_ +12V_BUS PSMN1R8-40YLC
R28 +12V_IN Net-_C42-Pad1_ 0.5mR
R24 /Power OR/CurentSensor12V Net-_Q9-Pad3_ 100K
R26 /Power OR/CurentSensor12V_Scale_100X GND 10K
Q9 /Power OR/CurentSensor12V_Scale_100X GND Net-_Q9-Pad3_ 2N7002
C36 +3V3 GND 1uF
C39 +3V3 GND 100pF
C42 Net-_C42-Pad1_ GND 1uF
U8 /Power OR/CurentSensor12V GND +12V_IN Net-_C42-Pad1_ +3V3 INA139
D2 Net-_C42-Pad1_ GND SMBJxxxAQ
R30 /Power OR/Enable_12V GND 10K
D4 +12V_BUS GND SMBJxxxAQ
C51 +12V_BUS GND 1uF
C49 +12V_BUS GND 100pF
C47 Net-_C47-Pad1_ GND 100pF
C53 +12V_BUS GND 2.2uF
R32 +12V_BUS Net-_C47-Pad1_ 100R
Q11 Net-_C42-Pad1_ Net-_C42-Pad1_ Net-_C42-Pad1_ Net-_Q11-Pad4_ +12V_BUS PSMN1R8-40YLC
U11 Net-_C47-Pad1_ GND /Power OR/Enable_12V Net-_C42-Pad1_ Net-_Q11-Pad4_ +12V_BUS LM5050-1
R20 /Power OR/CurentSensor12V Net-_Q7-Pad3_ 10K
R22 /Power OR/CurentSensor12V_Scale_10X GND 10K
Q7 /Power OR/CurentSensor12V_Scale_10X GND Net-_Q7-Pad3_ 2N7002
.end
