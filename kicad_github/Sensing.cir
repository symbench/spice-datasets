.title KiCad schematic
C102 Net-_C101-Pad1_ GND C_2.2uF
C101 Net-_C101-Pad1_ GND C_0.1uF
R103 Net-_COUT101-Pad1_ Net-_R102-Pad1_ R_100K
C103 Net-_C103-Pad1_ Net-_C103-Pad2_ C_0.1uF
COUT101 Net-_COUT101-Pad1_ GND C_22uF
COUT103 Net-_COUT101-Pad1_ GND C_47uF
COUT102 Net-_COUT101-Pad1_ GND C_33uF
R102 Net-_R102-Pad1_ GND R_25K
F101 Net-_C101-Pad1_ /12V F_500mA_16V
R104 Net-_COUT101-Pad1_ VCC R_0_2512
D103 GND Net-_D103-Pad2_ LED_0805
R105 VCC Net-_D103-Pad2_ R_200
D101 Net-_C101-Pad1_ GND D_Zener_18V
D102 GND Net-_D102-Pad2_ LED_0805
U2 /MISO /MOSI /HALL_EFFECT_SENSE VCC GND /CAN_TX /CAN_RX NC_01 /LINEAR_POT_SENSE Net-_C5-Pad1_ Net-_C4-Pad1_ /SCK NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 Net-_C3-Pad1_ GND NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 /RESET NC_18 ATMEGA16M1
R1 VCC Net-_C3-Pad1_ R_100
C3 Net-_C3-Pad1_ GND C_100pF
Y1 Net-_C4-Pad1_ GND Net-_C5-Pad1_ GND Crystal_SMD
C4 Net-_C4-Pad1_ GND C_30pF
C5 Net-_C5-Pad1_ GND C_30pF
R3 VCC /RESET R_10K
U1 /CAN_TX GND VCC /CAN_RX NC_19 /CAN_LO /CAN_HI GND MCP2561-E_SN
C1 VCC GND C_0.1uF
R2 /CAN_HI /CAN_LO R_200
J1 /MISO VCC /SCK /MOSI /RESET GND CONN_02X03
C2 VCC GND C_0.1uF
U101 Net-_C103-Pad1_ GND Net-_R102-Pad1_ Net-_C101-Pad1_ Net-_C101-Pad1_ Net-_C103-Pad2_ TPS560430YF
R101 Net-_C101-Pad1_ Net-_D102-Pad2_ R_1K
L101 Net-_C103-Pad2_ Net-_COUT101-Pad1_ L_100uH
U3 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 74HCT4051
U4 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 74HCT4051
J2 NC_52 /12V GND /CAN_P /CAN_N /12V GND NC_53 NC_54 /CAN_P /CAN_N GND /CAN_P /CAN_N /12V GND /12V GND /CAN_P /CAN_N /12V GND NC_55 Ampseal_23_VT
J4 GND /MISO /MOSI /SCK NC_56 GND NanoFit_RA_TH_06
J5 NC_57 NC_58 MicroFit_V_2
J6 NC_59 NC_60 MicroFit_V_2
J7 NC_61 NC_62 MicroFit_V_2
J8 NC_63 NC_64 MicroFit_V_2
J9 NC_65 NC_66 MicroFit_V_2
J10 NC_67 NC_68 MicroFit_V_2
J15 NC_69 NC_70 MicroFit_V_2
J16 NC_71 NC_72 MicroFit_V_2
J12 NC_73 NC_74 MicroFit_V_2
J13 NC_75 NC_76 MicroFit_V_2
J14 NC_77 NC_78 MicroFit_V_2
J11 NC_79 NC_80 MicroFit_V_2
J17 /12V GND /CAN_P /CAN_N /HALL_EFFECT_+ /HALL_EFFECT_SENSE NC_81 GND MM_M_VT_08
J18 /12V GND /CAN_P /CAN_N /LINEAR_POT_+ /LINEAR_POT_SENSE /LINEAR_POT_- GND MM_M_VT_08
J3 /HALL_EFFECT_+ /12V GND /CAN_P /CAN_N /12V GND /LINEAR_POT_+ /HALL_EFFECT_SENSE /CAN_P /CAN_N GND /CAN_P /CAN_N /12V GND /12V GND /CAN_P /CAN_N /12V GND /LINEAR_POT_- Ampseal_23_VT
.end
