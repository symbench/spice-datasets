.title KiCad schematic
K25 COL0 Net-_D23-Pad2_ KEYSW
D23 ROW1 Net-_D23-Pad2_ D
K26 COL1 Net-_D24-Pad2_ KEYSW
D24 ROW1 Net-_D24-Pad2_ D
K27 COL2 Net-_D25-Pad2_ KEYSW
D25 ROW1 Net-_D25-Pad2_ D
K28 COL3 Net-_D26-Pad2_ KEYSW
D26 ROW1 Net-_D26-Pad2_ D
K29 COL4 Net-_D27-Pad2_ KEYSW
D27 ROW1 Net-_D27-Pad2_ D
K30 COL5 Net-_D28-Pad2_ KEYSW
D28 ROW1 Net-_D28-Pad2_ D
K31 COL6 Net-_D29-Pad2_ KEYSW
D29 ROW1 Net-_D29-Pad2_ D
K32 COL7 Net-_D30-Pad2_ KEYSW
D30 ROW1 Net-_D30-Pad2_ D
K33 COL8 Net-_D31-Pad2_ KEYSW
D31 ROW1 Net-_D31-Pad2_ D
K34 COL9 Net-_D32-Pad2_ KEYSW
D32 ROW1 Net-_D32-Pad2_ D
K35 COL10 Net-_D33-Pad2_ KEYSW
D33 ROW1 Net-_D33-Pad2_ D
K36 COL11 Net-_D34-Pad2_ KEYSW
D34 ROW1 Net-_D34-Pad2_ D
K37 COL12 Net-_D35-Pad2_ KEYSW
D35 ROW1 Net-_D35-Pad2_ D
K38 COL13 Net-_D36-Pad2_ KEYSW
D36 ROW1 Net-_D36-Pad2_ D
K39 COL14 Net-_D37-Pad2_ KEYSW
D37 ROW1 Net-_D37-Pad2_ D
K40 COL15 Net-_D38-Pad2_ KEYSW
D38 ROW1 Net-_D38-Pad2_ D
K41 COL16 Net-_D39-Pad2_ KEYSW
D39 ROW1 Net-_D39-Pad2_ D
K42 COL17 Net-_D40-Pad2_ KEYSW
D40 ROW1 Net-_D40-Pad2_ D
K1 COL0 Net-_D1-Pad2_ KEYSW
D1 COL12 Net-_D1-Pad2_ D
K2 COL1 Net-_D2-Pad2_ KEYSW
D2 COL12 Net-_D2-Pad2_ D
K3 COL2 Net-_D3-Pad2_ KEYSW
D3 COL12 Net-_D3-Pad2_ D
K4 COL3 Net-_D4-Pad2_ KEYSW
D4 COL12 Net-_D4-Pad2_ D
K5 COL4 Net-_D5-Pad2_ KEYSW
D5 COL12 Net-_D5-Pad2_ D
K6 COL5 Net-_D6-Pad2_ KEYSW
D6 COL12 Net-_D6-Pad2_ D
K7 COL6 Net-_D7-Pad2_ KEYSW
D7 COL12 Net-_D7-Pad2_ D
K9 COL8 Net-_D9-Pad2_ KEYSW
D9 COL12 Net-_D9-Pad2_ D
K10 COL9 Net-_D10-Pad2_ KEYSW
D10 COL12 Net-_D10-Pad2_ D
K11 COL10 Net-_D11-Pad2_ KEYSW
D11 COL12 Net-_D11-Pad2_ D
K12 COL11 Net-_D12-Pad2_ KEYSW
D12 COL12 Net-_D12-Pad2_ D
K14 COL13 Net-_D14-Pad2_ KEYSW
D14 COL12 Net-_D14-Pad2_ D
K15 COL14 Net-_D15-Pad2_ KEYSW
D15 COL12 Net-_D15-Pad2_ D
K16 COL15 Net-_D16-Pad2_ KEYSW
D16 COL12 Net-_D16-Pad2_ D
K17 COL16 Net-_D17-Pad2_ KEYSW
D17 COL12 Net-_D17-Pad2_ D
K18 COL17 Net-_D18-Pad2_ KEYSW
D18 COL12 Net-_D18-Pad2_ D
K47 COL16 Net-_D39-Pad2_ KEYSW
K48 COL0 Net-_D45-Pad2_ KEYSW
D45 ROW2 Net-_D45-Pad2_ D
K49 COL1 Net-_D46-Pad2_ KEYSW
D46 ROW2 Net-_D46-Pad2_ D
K50 COL2 Net-_D47-Pad2_ KEYSW
D47 ROW2 Net-_D47-Pad2_ D
K51 COL3 Net-_D48-Pad2_ KEYSW
D48 ROW2 Net-_D48-Pad2_ D
K52 COL4 Net-_D49-Pad2_ KEYSW
D49 ROW2 Net-_D49-Pad2_ D
K53 COL5 Net-_D50-Pad2_ KEYSW
D50 ROW2 Net-_D50-Pad2_ D
K54 COL6 Net-_D51-Pad2_ KEYSW
D51 ROW2 Net-_D51-Pad2_ D
K55 COL7 Net-_D52-Pad2_ KEYSW
D52 ROW2 Net-_D52-Pad2_ D
K56 COL8 Net-_D53-Pad2_ KEYSW
D53 ROW2 Net-_D53-Pad2_ D
K57 COL9 Net-_D54-Pad2_ KEYSW
D54 ROW2 Net-_D54-Pad2_ D
K58 COL10 Net-_D55-Pad2_ KEYSW
D55 ROW2 Net-_D55-Pad2_ D
K59 COL11 Net-_D56-Pad2_ KEYSW
D56 ROW2 Net-_D56-Pad2_ D
K60 COL12 Net-_D57-Pad2_ KEYSW
D57 ROW2 Net-_D57-Pad2_ D
K61 COL13 Net-_D58-Pad2_ KEYSW
D58 ROW2 Net-_D58-Pad2_ D
K62 COL14 Net-_D59-Pad2_ KEYSW
D59 ROW2 Net-_D59-Pad2_ D
K63 COL16 Net-_D60-Pad2_ KEYSW
D60 ROW2 Net-_D60-Pad2_ D
K64 COL17 Net-_D61-Pad2_ KEYSW
D61 ROW2 Net-_D61-Pad2_ D
K69 COL0 Net-_D66-Pad2_ KEYSW
D66 ROW3 Net-_D66-Pad2_ D
K70 COL1 Net-_D67-Pad2_ KEYSW
D67 ROW3 Net-_D67-Pad2_ D
K71 COL2 Net-_D68-Pad2_ KEYSW
D68 ROW3 Net-_D68-Pad2_ D
K72 COL3 Net-_D69-Pad2_ KEYSW
D69 ROW3 Net-_D69-Pad2_ D
K73 COL4 Net-_D70-Pad2_ KEYSW
D70 ROW3 Net-_D70-Pad2_ D
K74 COL5 Net-_D71-Pad2_ KEYSW
D71 ROW3 Net-_D71-Pad2_ D
K75 COL6 Net-_D72-Pad2_ KEYSW
D72 ROW3 Net-_D72-Pad2_ D
K76 COL7 Net-_D73-Pad2_ KEYSW
D73 ROW3 Net-_D73-Pad2_ D
K77 COL8 Net-_D74-Pad2_ KEYSW
D74 ROW3 Net-_D74-Pad2_ D
K78 COL9 Net-_D75-Pad2_ KEYSW
D75 ROW3 Net-_D75-Pad2_ D
K79 COL10 Net-_D76-Pad2_ KEYSW
D76 ROW3 Net-_D76-Pad2_ D
K80 COL11 Net-_D77-Pad2_ KEYSW
D77 ROW3 Net-_D77-Pad2_ D
K81 COL12 Net-_D78-Pad2_ KEYSW
D78 ROW3 Net-_D78-Pad2_ D
K82 COL13 Net-_D79-Pad2_ KEYSW
D79 ROW3 Net-_D79-Pad2_ D
K83 COL14 Net-_D80-Pad2_ KEYSW
D80 ROW3 Net-_D80-Pad2_ D
K84 COL17 Net-_D81-Pad2_ KEYSW
D81 ROW3 Net-_D81-Pad2_ D
K90 COL0 Net-_D86-Pad2_ KEYSW
D86 ROW4 Net-_D86-Pad2_ D
K91 COL1 Net-_D87-Pad2_ KEYSW
D87 ROW4 Net-_D87-Pad2_ D
K92 COL2 Net-_D88-Pad2_ KEYSW
D88 ROW4 Net-_D88-Pad2_ D
K93 COL3 Net-_D89-Pad2_ KEYSW
D89 ROW4 Net-_D89-Pad2_ D
K94 COL4 Net-_D90-Pad2_ KEYSW
D90 ROW4 Net-_D90-Pad2_ D
K95 COL5 Net-_D91-Pad2_ KEYSW
D91 ROW4 Net-_D91-Pad2_ D
K96 COL6 Net-_D92-Pad2_ KEYSW
D92 ROW4 Net-_D92-Pad2_ D
K97 COL7 Net-_D93-Pad2_ KEYSW
D93 ROW4 Net-_D93-Pad2_ D
K98 COL8 Net-_D94-Pad2_ KEYSW
D94 ROW4 Net-_D94-Pad2_ D
K99 COL9 Net-_D95-Pad2_ KEYSW
D95 ROW4 Net-_D95-Pad2_ D
K100 COL10 Net-_D96-Pad2_ KEYSW
D96 ROW4 Net-_D96-Pad2_ D
K101 COL11 Net-_D97-Pad2_ KEYSW
D97 ROW4 Net-_D97-Pad2_ D
K102 COL12 Net-_D98-Pad2_ KEYSW
D98 ROW4 Net-_D98-Pad2_ D
K103 COL13 Net-_D99-Pad2_ KEYSW
D99 ROW4 Net-_D99-Pad2_ D
K104 COL14 Net-_D100-Pad2_ KEYSW
D100 ROW4 Net-_D100-Pad2_ D
K105 COL16 Net-_D101-Pad2_ KEYSW
D101 ROW4 Net-_D101-Pad2_ D
K106 COL17 Net-_D102-Pad2_ KEYSW
D102 ROW4 Net-_D102-Pad2_ D
K111 COL3 Net-_D89-Pad2_ KEYSW
K126 COL0 Net-_D107-Pad2_ KEYSW
D107 ROW5 Net-_D107-Pad2_ D
K127 COL1 Net-_D108-Pad2_ KEYSW
D108 ROW5 Net-_D108-Pad2_ D
K128 COL2 Net-_D109-Pad2_ KEYSW
D109 ROW5 Net-_D109-Pad2_ D
K130 COL5 Net-_D111-Pad2_ KEYSW
D111 ROW5 Net-_D111-Pad2_ D
D112 ROW5 Net-_D112-Pad2_ D
D114 ROW5 Net-_D114-Pad2_ D
K134 Net-_K115-Pad1_ Net-_D115-Pad2_ KEYSW
K120 Net-_K115-Pad1_ Net-_D115-Pad2_ KEYSW
D115 ROW5 Net-_D115-Pad2_ D
K135 COL13 Net-_D116-Pad2_ KEYSW
D116 ROW5 Net-_D116-Pad2_ D
K136 COL14 Net-_D117-Pad2_ KEYSW
D117 ROW5 Net-_D117-Pad2_ D
K137 COL16 Net-_D118-Pad2_ KEYSW
D118 ROW5 Net-_D118-Pad2_ D
K138 COL17 Net-_D119-Pad2_ KEYSW
D119 ROW5 Net-_D119-Pad2_ D
U2 COL17 COL18 COL19 ROW1 ROW2 ROW3 ROW4 GND VCC ROW5 COL12 COL5 COL6 COL7 COL8 COL4 COL3 GND VCC COL2 COL1 COL0 NC_01 NC_02 COL21 Net-_J1-PadA7_ Net-_J1-PadA6_ NC_03 NC_04 GND VCC COL20 COL15 PDI RST COL14 COL13 GND VCC COL12 COL11 COL10 COL9 COL16 ATXMEGA-A4U
J1 GND +5V Net-_J1-PadA5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_05 +5V GND GND +5V Net-_J1-PadB5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_06 +5V GND GND USB_Type_C_2.0_Receptacle
P1 PDI VCC NC_07 NC_08 RST GND TC2030-IDC
U1 +5V GND +5V NC_09 VCC MIC550X
R1 Net-_J1-PadB5_ GND 5.1k
R2 Net-_J1-PadA5_ GND 5.1k
C2 VCC GND 0.4uf
C1 VCC GND 10uf
K129 COL3 Net-_D110-Pad2_ KEYSW
D110 ROW5 Net-_D110-Pad2_ D
B1 NC_10 NC_11 NC_12 NC_13 COL20 COL21 COL12 ROW5 ROW4 ROW3 ROW2 ROW1 COL19 COL18 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 SPARKFUN_PRO_MICRO
K143 COL2 Net-_D109-Pad2_ KEYSW
K144 COL3 Net-_D110-Pad2_ KEYSW
K145 COL5 Net-_D111-Pad2_ KEYSW
K8 COL7 Net-_D8-Pad2_ KEYSW
D8 COL12 Net-_D8-Pad2_ D
K13 COL12 Net-_D13-Pad2_ KEYSW
D13 COL12 Net-_D13-Pad2_ D
K23 COL7 Net-_D8-Pad2_ KEYSW
K24 COL12 Net-_D13-Pad2_ KEYSW
K117 NC_24 NC_25 KEYSW
K121 COL3 Net-_D110-Pad2_ KEYSW
K125 COL13 Net-_D116-Pad2_ KEYSW
K115 Net-_K115-Pad1_ Net-_D115-Pad2_ KEYSW
K118 COL7 Net-_D112-Pad2_ KEYSW
K122 COL7 Net-_D112-Pad2_ KEYSW
K133 COL10 Net-_D114-Pad2_ KEYSW
K124 COL10 Net-_D114-Pad2_ KEYSW
D113 ROW5 Net-_D113-Pad2_ D
K123 ROW4 Net-_D113-Pad2_ KEYSW
K119 ROW4 Net-_D113-Pad2_ KEYSW
K116 ROW4 Net-_D113-Pad2_ KEYSW
K114 ROW4 Net-_D113-Pad2_ KEYSW
K113 ROW4 Net-_D113-Pad2_ KEYSW
K112 ROW4 Net-_D113-Pad2_ KEYSW
K155 COL13 Net-_D116-Pad2_ KEYSW
K43 COL18 Net-_D41-Pad2_ KEYSW
D41 ROW1 Net-_D41-Pad2_ D
K44 COL19 Net-_D42-Pad2_ KEYSW
D42 ROW1 Net-_D42-Pad2_ D
K45 COL20 Net-_D43-Pad2_ KEYSW
D43 ROW1 Net-_D43-Pad2_ D
K46 COL21 Net-_D44-Pad2_ KEYSW
D44 ROW1 Net-_D44-Pad2_ D
K19 COL18 Net-_D19-Pad2_ KEYSW
D19 COL12 Net-_D19-Pad2_ D
K20 COL19 Net-_D20-Pad2_ KEYSW
D20 COL12 Net-_D20-Pad2_ D
K21 COL20 Net-_D21-Pad2_ KEYSW
D21 COL12 Net-_D21-Pad2_ D
K22 COL21 Net-_D22-Pad2_ KEYSW
D22 COL12 Net-_D22-Pad2_ D
K65 COL18 Net-_D62-Pad2_ KEYSW
D62 ROW2 Net-_D62-Pad2_ D
K66 COL19 Net-_D63-Pad2_ KEYSW
D63 ROW2 Net-_D63-Pad2_ D
K67 COL20 Net-_D64-Pad2_ KEYSW
D64 ROW2 Net-_D64-Pad2_ D
K68 COL21 Net-_D65-Pad2_ KEYSW
D65 ROW2 Net-_D65-Pad2_ D
K89 COL21 Net-_D85-Pad2_ KEYSW
K85 COL18 Net-_D82-Pad2_ KEYSW
D82 ROW3 Net-_D82-Pad2_ D
K86 COL19 Net-_D83-Pad2_ KEYSW
D83 ROW3 Net-_D83-Pad2_ D
K87 COL20 Net-_D84-Pad2_ KEYSW
D84 ROW3 Net-_D84-Pad2_ D
K88 COL21 Net-_D85-Pad2_ KEYSW
D85 ROW3 Net-_D85-Pad2_ D
K107 COL18 Net-_D103-Pad2_ KEYSW
D103 ROW4 Net-_D103-Pad2_ D
K108 COL19 Net-_D104-Pad2_ KEYSW
D104 ROW4 Net-_D104-Pad2_ D
K109 COL20 Net-_D105-Pad2_ KEYSW
D105 ROW4 Net-_D105-Pad2_ D
K110 COL21 Net-_D106-Pad2_ KEYSW
D106 ROW4 Net-_D106-Pad2_ D
K153 COL21 Net-_D123-Pad2_ KEYSW
K139 COL18 Net-_D120-Pad2_ KEYSW
D120 ROW5 Net-_D120-Pad2_ D
K140 COL19 Net-_D121-Pad2_ KEYSW
D121 ROW5 Net-_D121-Pad2_ D
K141 COL20 Net-_D122-Pad2_ KEYSW
D122 ROW5 Net-_D122-Pad2_ D
D123 ROW5 Net-_D123-Pad2_ D
K152 COL18 Net-_D120-Pad2_ KEYSW
K142 COL21 Net-_D123-Pad2_ KEYSW
K147 COL10 Net-_D114-Pad2_ KEYSW
.end
