.title KiCad schematic
S1 Net-_R5-Pad2_ Net-_S1-Pad2_ /LS1 GND qre1113
S2 Net-_S1-Pad2_ Net-_S2-Pad2_ /LS2 GND qre1113
S3 Net-_S2-Pad2_ Net-_S3-Pad2_ /LS3 GND qre1113
S4 Net-_S3-Pad2_ Net-_Q1-Pad2_ /LS4 GND qre1113
S5 Net-_R12-Pad2_ Net-_S5-Pad2_ /LS5 GND qre1113
S6 Net-_S5-Pad2_ Net-_S6-Pad2_ /LS6 GND qre1113
S7 Net-_S6-Pad2_ Net-_S7-Pad2_ /LS7 GND qre1113
S8 Net-_S7-Pad2_ Net-_Q1-Pad2_ /LS8 GND qre1113
R12 +9V Net-_R12-Pad2_ 150
R5 +9V Net-_R5-Pad2_ 150
R1 /LS1 +5V 10K
R2 /LS2 +5V 10K
R3 /LS3 +5V 10K
R4 /LS4 +5V 10K
R7 /LS5 +5V 10K
R8 /LS6 +5V 10K
R9 /LS7 +5V 10K
R10 /LS8 +5V 10K
R11 /XY Net-_Q1-Pad1_ 1K
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ GND Q_NPN_BCE
MCP1 NC_01 NC_02 /ML1 /ML2 NC_03 GND /MD1 /MD2 /C3 /CL1 /CL2 /BTX /BRX NC_04 NC_05 /BUT NC_06 /BUZZ +3V3 NC_07 /MUX /VBAT /XY /C0 /C1 /C2 NC_08 NC_09 +5V NC_10 GND +9V NC_11 NC_12 ArduinoMicro
U2 /MUX /LS8 /LS7 /LS6 /LS5 /LS4 /LS3 /LS2 /LS1 /C0 /C1 GND /C3 /C2 GND NC_13 NC_14 NC_15 NC_16 NC_17 /LS11 /LS10 /LS9 +5V CD74HC4067
BT1 +9VA GND Battery_Cell 9V
C1 +9VA GND 22uF
U5 +9VA Net-_Q2-Pad1_ GND SW1
R17 +9VA Net-_Q2-Pad1_ 10K
Q2 Net-_Q2-Pad1_ +9V +9VA Q_PMOS_GDS
R18 /VBAT +9V 10K
R19 GND /VBAT 10K
U8 +5V /CL1 Net-_C3-Pad1_ GND GND Net-_C3-Pad2_ /CL2 +9V +5V NC_18 Net-_C2-Pad2_ GND GND Net-_C2-Pad1_ NC_19 +9V SN754410
U6 Net-_C3-Pad1_ Net-_C3-Pad2_ +5V /ML1 /ML2 GND Motor
U7 Net-_C2-Pad1_ Net-_C2-Pad2_ +5V /MD1 /MD2 GND Motor
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ C
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ C
BZ1 /BUZZ GND Buzzer
U3 GND NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 +3V3 GND Net-_U3-Pad13_ Net-_U3-Pad14_ NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 GND GND NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 RN42
U4 +3V3 Net-_U3-Pad14_ Net-_U3-Pad13_ NC_45 NC_46 NC_47 +3V3 NC_48 NC_49 NC_50 /BRX /BTX +5V TXB0104-Q1
R16 +9V Net-_R16-Pad2_ 220
S9 Net-_R16-Pad2_ Net-_S10-Pad1_ /LS9 GND qre1113
S10 Net-_S10-Pad1_ Net-_S10-Pad2_ /LS10 GND qre1113
S11 Net-_S10-Pad2_ NC_51 /LS11 GND qre1113
R13 /LS9 +5V 10K
R14 /LS10 +5V 10K
R15 /LS11 +5V 10K
R6 +5V /BUT 10K
U1 /BUT GND BUT_SW
.end
