.title KiCad schematic
Q1 MOTOR_U MOTOR_U MOTOR_U GH_A VPP U_HIGH
Q2 SL_A SL_A SL_A GL_A MOTOR_U U_LOW
R1 SL_A SN_DC_BUS Shunt U
C1 SL_A SN_DC_BUS 1000pF
R4 SN_DC_BUS SP_DC_BUS DC_BUS
Q3 MOTOR_V MOTOR_V MOTOR_V GH_B VPP V_HIGH
Q4 SL_B SL_B SL_B GL_B MOTOR_V V_LOW
R5 SL_B SN_DC_BUS Shunt V
C7 SL_B SN_DC_BUS 1000pF
Q5 MOTOR_W MOTOR_W MOTOR_W GH_C VPP W_HIGH
Q6 SL_C SL_C SL_C GL_C MOTOR_W W_LOW
R9 SL_C SN_DC_BUS Shunt W
C9 SL_C SN_DC_BUS 1000pF
C8 SP_DC_BUS SN_DC_BUS 1000pF
J5 MOTOR_U MOTOR_V MOTOR_W MOTOR
R13 MOTOR_U V_SENSE_A R
R14 V_SENSE_A SP_DC_BUS R
R15 MOTOR_V V_SENSE_B R
R16 V_SENSE_B SP_DC_BUS R
R17 MOTOR_W V_SENSE_C R
R18 V_SENSE_C SP_DC_BUS R
J1 Net-_2N4001-Pad2_ SP_DC_BUS MOTOR_PWR
2N4001 VPP Net-_2N4001-Pad2_ D
C2 VPP SP_DC_BUS 0.01uF
C3 VPP SP_DC_BUS 0.1uF
C4 VPP SP_DC_BUS 470uF
C5 VPP SP_DC_BUS 470uF
R2 VPP PVDD_SENSE VSenseUpper
R3 PVDD_SENSE SP_DC_BUS VSenseLower
C6 PVDD_SENSE SP_DC_BUS 0.1uF
1N5817 VPP PVDD_SENSE D
U1 V_SENSE_A SP_DC_BUS V_SENSE_B V_SENSE_C VDD_MCU PVDD_SENSE CSRV065V0P
U2 SP_DC_BUS +3V3 VPP LD1117S33CTR
U3 SP_DC_BUS +5V VPP LD1117S50TR
J2 +3V3 VDD_MCU +5V MCU_V_Select
U4 MCU_HALL_A Net-_C10-Pad2_ MCU_HALL_B SP_DC_BUS Net-_C11-Pad2_ MCU_HALL_C Net-_C12-Pad2_ VDD_MCU SN74LVC3G07MDCUREP
R8 VDD_MCU MCU_HALL_A 10k
R7 VDD_MCU MCU_HALL_B 10k
R6 VDD_MCU MCU_HALL_C 10k
R12 Net-_J3-Pad2_ Net-_C12-Pad2_ 1k
R11 Net-_J3-Pad2_ Net-_C11-Pad2_ 1k
R10 Net-_J3-Pad2_ Net-_C10-Pad2_ 1k
J3 VPP Net-_J3-Pad2_ +5V HALL_V
C10 SP_DC_BUS Net-_C10-Pad2_ 1000pF
C11 SP_DC_BUS Net-_C11-Pad2_ 1000pF
C12 SP_DC_BUS Net-_C12-Pad2_ 1000pF
J6 VDD_MCU SP_DC_BUS GH_A MOTOR_U GL_A SL_A GH_B MOTOR_V GL_B SL_B GH_C MOTOR_W GL_C SL_C SL_A SN_DC_BUS SL_B SN_DC_BUS SL_C SN_DC_BUS SN_DC_BUS SP_DC_BUS MCU_HALL_A MCU_HALL_B MCU_HALL_C PVDD_SENSE V_SENSE_A V_SENSE_B V_SENSE_C Drive_Conn
J4 Net-_J3-Pad2_ Net-_C12-Pad2_ Net-_C11-Pad2_ Net-_C10-Pad2_ SP_DC_BUS HALL_IN
.end
