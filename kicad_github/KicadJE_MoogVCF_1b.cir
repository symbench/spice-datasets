.title KiCad schematic
R215 Net-_Q3-Pad6_ +12V 22R
R220 Net-_C211-Pad1_ Net-_R217-Pad1_ 56k
R230 -12V Net-_Q3-Pad1_ 270k
Q212 /KicadJE_Yousynth_MoogVCF_revB/PNP_B /KicadJE_Yousynth_MoogVCF_revB/PNP_E Net-_Q212-Pad3_ SS9015
R222 Net-_R217-Pad2_ OutVCF 1k
R227 GND Net-_C2-Pad2_ 47k
C211 Net-_C211-Pad1_ Net-_C211-Pad2_ 10u
R216 /KicadJE_Yousynth_MoogVCF_revB/Coupling Net-_C211-Pad2_ 1k
TP201 Net-_C211-Pad2_ PreOut
R214 /KicadJE_Yousynth_MoogVCF_revB/Coupling +12V 180R
Q206 Net-_Q206-Pad1_ Net-_C210-Pad2_ Net-_C209-Pad2_ SS9014
R231 -12V NC_01 1k2
R232 -12V Net-_Q3-Pad5_ 270k
U201 Net-_R217-Pad2_ Net-_R217-Pad1_ GND -12V GND Net-_R218-Pad2_ Net-_R219-Pad2_ +12V TL072
Q3 Net-_Q3-Pad1_ Net-_C3-Pad2_ Net-_C211-Pad2_ Net-_Q3-Pad4_ Net-_Q3-Pad5_ Net-_Q3-Pad6_ UMX1N
Q4 Net-_Q3-Pad4_ Net-_Q3-Pad1_ Net-_C211-Pad2_ Net-_Q3-Pad5_ Net-_C2-Pad2_ Net-_Q3-Pad6_ UMX1N
R226 GND Net-_C3-Pad2_ 47k
R217 Net-_R217-Pad1_ Net-_R217-Pad2_ 120k
Q1 Net-_C2-Pad1_ Net-_Q1-Pad2_ +12V Net-_C207-Pad1_ Net-_Q1-Pad2_ +12V UMX1N
Q2 Net-_Q2-Pad1_ Net-_C212-Pad1_ Net-_C210-Pad1_ Net-_Q2-Pad1_ Net-_Q2-Pad5_ Net-_C210-Pad2_ UMX1N
Q207 Net-_Q206-Pad1_ Net-_C210-Pad1_ Net-_C209-Pad1_ SS9014
C209 Net-_C209-Pad1_ Net-_C209-Pad2_ 47n
Q204 Net-_Q204-Pad1_ Net-_C209-Pad2_ Net-_C208-Pad2_ SS9014
Q205 Net-_Q204-Pad1_ Net-_C209-Pad1_ Net-_C208-Pad1_ SS9014
C208 Net-_C208-Pad1_ Net-_C208-Pad2_ 47n
Q202 Net-_Q202-Pad1_ Net-_C208-Pad2_ Net-_C2-Pad1_ SS9014
Q203 Net-_Q202-Pad1_ Net-_C208-Pad1_ Net-_C207-Pad1_ SS9014
C207 Net-_C207-Pad1_ Net-_C2-Pad1_ 47n
C210 Net-_C210-Pad1_ Net-_C210-Pad2_ 47n
R201 Net-_Q1-Pad2_ +12V 330R
R206 Net-_Q202-Pad1_ Net-_Q1-Pad2_ 150R
R210 Net-_Q204-Pad1_ Net-_Q202-Pad1_ 150R
R213 Net-_Q206-Pad1_ Net-_Q204-Pad1_ 150R
Q211 /KicadJE_Yousynth_MoogVCF_revB/PNP_E GND Net-_Q211-Pad3_ SS9014
R228 Net-_Q211-Pad3_ Net-_Q2-Pad1_ 1k
R225 Net-_C1-Pad1_ Net-_C212-Pad1_ 470R
R224 Net-_C1-Pad1_ Net-_Q206-Pad1_ 150R
R229 Net-_C1-Pad1_ Net-_R229-Pad2_ 330R
R233 GND Net-_C1-Pad1_ 220R
RV5 Net-_R211-Pad1_ Net-_Q2-Pad5_ Net-_R229-Pad2_ 1k
RV7 Net-_R211-Pad1_ Net-_R211-Pad2_ /KicadJE_Yousynth_MoogVCF_revB/Coupling 50k_emphasis
R211 Net-_R211-Pad1_ Net-_R211-Pad2_ 0R
R212 /KicadJE_Yousynth_MoogVCF_revB/Coupling Net-_R211-Pad2_ Open
TP202 Net-_C212-Pad1_ Input
R239 GND Net-_Q212-Pad3_ 470R
C214 GND Net-_C1-Pad1_ 22u
C1 Net-_C1-Pad1_ GND Opt_220u
C215 GND /KicadJE_Yousynth_MoogVCF_revB/PNP_B 100p
RV4 Net-_R237-Pad1_ GND GND 500R
R237 Net-_R237-Pad1_ /KicadJE_Yousynth_MoogVCF_revB/PNP_B 1k8
R219 Net-_R218-Pad2_ Net-_R219-Pad2_ 56k
R223 Net-_R219-Pad2_ Net-_C212-Pad2_ 10k
R218 InAudio1 Net-_R218-Pad2_ 120k
C212 Net-_C212-Pad1_ Net-_C212-Pad2_ 10u
R221 InAudio2 Net-_R218-Pad2_ 120k
RV2 CV1 Net-_R238-Pad1_ GND 50k_CV1
R234 Net-_R234-Pad1_ /KicadJE_Yousynth_MoogVCF_revB/PNP_B 100k
R238 Net-_R238-Pad1_ /KicadJE_Yousynth_MoogVCF_revB/PNP_B 100k
RV3 Net-_R235-Pad1_ Net-_R236-Pad2_ GND 10k_Freq
R236 /KicadJE_Yousynth_MoogVCF_revB/PNP_B Net-_R236-Pad2_ 150k
R235 Net-_R235-Pad1_ +12V 680R
RV1 CV2 Net-_R234-Pad1_ GND 50k_CV2
D204 GND Net-_D203-Pad2_ Zener
D203 CV2 Net-_D203-Pad2_ Zener
J201 GND Net-_J201-PadT_ GND CV2
R204 CV2 GND OPEN
R202 Net-_J201-PadT_ CV2 1K
D208 GND Net-_D207-Pad2_ Zener
D207 CV1 Net-_D207-Pad2_ Zener
D205 InAudio2 Net-_D205-Pad2_ Zener
D206 GND Net-_D205-Pad2_ Zener
C204 -12V GND 10u
C201 GND +12V 10u
R208 Net-_J204-PadT_ OutVCF 0R
J202 GND Net-_J202-PadT_ GND Input2
J204 GND Net-_J204-PadT_ Out VCF
J203 GND Net-_J203-PadT_ GND CV1
R209 CV1 GND OPEN
R207 Net-_J203-PadT_ CV1 1K
R205 InAudio2 GND OPEN
R203 Net-_J202-PadT_ InAudio2 1K
P201 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
H203 2,2mm
H204 2,2mm
H202 2,5mm
H201 2,5mm
D202 GND -12V 1N1007
D201 +12V GND 1N1007
C203 GND +12V 100n
C206 -12V GND 100n
C205 -12V GND 100n
C202 GND +12V 100n
J205 GND Net-_J205-PadT_ GND Input1
R241 InAudio1 GND OPEN
R240 Net-_J205-PadT_ InAudio1 1K
D209 InAudio1 Net-_D209-Pad2_ Zener
D210 GND Net-_D209-Pad2_ Zener
R242 -12V Net-_D1-Pad1_ 12K
D1 Net-_D1-Pad1_ GND LED
RV6 +12V Net-_R243-Pad2_ GND 10k
R243 /KicadJE_Yousynth_MoogVCF_revB/PNP_E Net-_R243-Pad2_ 100k
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 220n
C3 Net-_C207-Pad1_ Net-_C3-Pad2_ 220n
C302 GND +12V 100n
C301 GND +12V 1u
C304 GND -12V 100n
C303 GND -12V 1u
D301 +12V GND 1N1007
D302 GND -12V 1N1007
J302 GND ADSR_out ADSR
J301 Net-_J301-PadS_ Net-_J301-PadT_ Net-_J301-PadS_ ADSRGate
U302 GND 555_Trig 555_Out 555_RST Net-_C305-Pad1_ 555_Threshold 555_Dis +12V TLC555
C305 Net-_C305-Pad1_ GND 10n
R322 Net-_J301-PadT_ ADSRGate 47k
D306 +12V ADSRGate 1N1007
D307 ADSRGate GND 1N1007
RV303 Net-_R305-Pad2_ Net-_RV303-Pad2_ Net-_Q301-Pad3_ 10k Sust
R311 +12V Net-_Q302-Pad1_ 22k
R310 +12V 555_RST 22k
R320 Net-_Q302-Pad2_ GND 10R
R314 Net-_Q303-Pad1_ ADSRGate 1M
R313 Net-_Q303-Pad1_ Net-_R313-Pad2_ 47k
R317 GND ADSRGate 1M2
R309 +12V Net-_R309-Pad2_ 10k
SW302 Net-_R313-Pad2_ Net-_R309-Pad2_ Gate
C308 Net-_C308-Pad1_ 555_RST 10n
R321 Net-_C308-Pad1_ GND 22k
R312 +12V 555_Trig 22k
Q301 555_RST 555_Dis Net-_Q301-Pad3_ SI2302
R305 +12V Net-_R305-Pad2_ 4k7
U301 Net-_D304-Pad1_ Net-_D304-Pad1_ Net-_RV303-Pad2_ -12V Net-_C307-Pad2_ 555_Threshold 555_Threshold +12V TL072
D304 Net-_D304-Pad1_ Net-_D304-Pad2_ 1N4148
RV302 Net-_D304-Pad2_ Net-_R306-Pad2_ Net-_R307-Pad1_ 1M Decay
R306 Net-_D304-Pad2_ Net-_R306-Pad2_ 0R
R307 Net-_R307-Pad1_ Net-_R306-Pad2_ Open / 300K if lin pot
RV304 Net-_D305-Pad2_ Net-_R315-Pad2_ Net-_R316-Pad1_ 1M Release
R315 Net-_D305-Pad2_ Net-_R315-Pad2_ 0R
R316 Net-_R316-Pad1_ Net-_R315-Pad2_ Open / 300K if lin pot
RV301 Net-_R301-Pad1_ Net-_R301-Pad2_ 555_Out 1M Attack
R301 Net-_R301-Pad1_ Net-_R301-Pad2_ 0R
R302 555_Out Net-_R301-Pad2_ Open / 300K if lin pot
R308 Net-_C307-Pad2_ Net-_R307-Pad1_ 100R
SW301 Net-_R304-Pad2_ Net-_D303-Pad2_ NC_02 Net-_C307-Pad2_ Net-_C307-Pad2_ Net-_C306-Pad2_ SW_DPDT_x2
C306 GND Net-_C306-Pad2_ 10u_N/A
C307 GND Net-_C307-Pad2_ 1u
R304 Net-_R301-Pad1_ Net-_R304-Pad2_ 120R_N/A
R303 Net-_R301-Pad1_ Net-_D303-Pad2_ 680R
D303 Net-_C307-Pad2_ Net-_D303-Pad2_ 1N4148
R319 Net-_C307-Pad2_ Net-_R316-Pad1_ 100R
D305 555_RST Net-_D305-Pad2_ 1N4148
R318 ADSR_out 555_Threshold 1k
Q303 Net-_Q303-Pad1_ Net-_Q302-Pad2_ Net-_Q302-Pad1_ MMBT3904
Q302 Net-_Q302-Pad1_ Net-_Q302-Pad2_ 555_RST MMBT3904
Q304 Net-_C308-Pad1_ GND 555_Trig MMBT3904
P301 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
C402 GND +12V 100n
C401 GND +12V 1u
C404 GND -12V 100n
C403 GND -12V 1u
D401 +12V GND 1N1007
D404 GND -12V 1N1007
R421 Net-_Q402-Pad1_ Net-_R418-Pad1_ 22k
U401 Net-_R418-Pad1_ Net-_R417-Pad1_ GND -12V Net-_R413-Pad1_ Net-_R409-Pad2_ Output_VCA +12V TL072
P401 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
J402 GND Net-_J402-PadT_ Output
J401 GND Net-_J401-PadT_ GND CV
R401 Net-_J401-PadT_ CV_Fold 10k
D402 +12V CV_Fold 1N1007
D403 CV_Fold GND 1N1007
J404 GND Net-_J404-PadT_ GND Input
R405 Net-_J404-PadT_ Input_Fold 10k
D406 +12V Input_Fold 1N1007
D407 Input_Fold -12V 1N1007
R402 Output_Fold Net-_J402-PadT_ 470R
U402 Net-_D416-Pad1_ Net-_C407-Pad1_ GND +12V GND Net-_C406-Pad2_ Net-_R406-Pad2_ Net-_D426-Pad1_ Net-_D422-Pad2_ GND -12V GND Net-_R430-Pad1_ Net-_C408-Pad1_ TL074
H401 2,2mm
H402 2,2mm
R403 -12V Net-_D405-Pad1_ 12K
D405 Net-_D405-Pad1_ GND LED
Q401 Net-_Q401-Pad1_ Net-_C405-Pad1_ Net-_Q401-Pad3_ Net-_Q401-Pad1_ GND Net-_Q401-Pad6_ UMX1N
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ GND SS9014
R420 Net-_Q402-Pad2_ Net-_Q401-Pad1_ 33k
R414 GND Net-_C405-Pad1_ 680R
R425 -12V Net-_Q402-Pad2_ 15k
R435 Net-_D426-Pad1_ Net-_R432-Pad1_ Open
RV404 -12V Net-_R423-Pad1_ +12V 50k
TP401 Net-_C405-Pad1_ Input
C408 Net-_C408-Pad1_ Output_Fold 22u Opt
C405 Net-_C405-Pad1_ Net-_C405-Pad2_ 1u/0R
R423 Net-_R423-Pad1_ Net-_Q402-Pad1_ 22k
R418 Net-_R418-Pad1_ Net-_R417-Pad1_ 100k
RV403 +12V Net-_R422-Pad1_ GND 100k Range
R422 Net-_R422-Pad1_ Net-_R417-Pad1_ 100k
R417 Net-_R417-Pad1_ Net-_R417-Pad2_ 68k
RV402 CV_Fold Net-_R417-Pad2_ GND 100k CV
R412 Net-_C405-Pad2_ Input_Fold 100k
RV401 Net-_R408-Pad2_ +12V Net-_R407-Pad2_ 1k
R408 Net-_Q401-Pad3_ Net-_R408-Pad2_ 15k 1%
R407 Net-_Q401-Pad6_ Net-_R407-Pad2_ 15k 1%
R410 Net-_R409-Pad2_ Net-_Q401-Pad6_ 10k 1%
R413 Net-_R413-Pad1_ Net-_Q401-Pad3_ 10k 1%
R409 Output_VCA Net-_R409-Pad2_ 100k 1%
R415 GND Net-_R413-Pad1_ 100k 1%
J403 GND Net-_J403-PadT_ VCA Out
R404 Output_VCA Net-_J403-PadT_ 470R
R440 Net-_D422-Pad2_ Output_VCA 100k
R439 Net-_D426-Pad1_ Net-_D422-Pad2_ 100k
R437 Net-_D426-Pad1_ Net-_D422-Pad1_ 33k
R436 GND Net-_D422-Pad1_ 2k7
D423 Net-_D422-Pad2_ Net-_D422-Pad1_ LL4148
D422 Net-_D422-Pad1_ Net-_D422-Pad2_ LL4148
RV405 Net-_R428-Pad1_ Net-_R432-Pad1_ Net-_D426-Pad1_ 100k Shape
R432 Net-_R432-Pad1_ Net-_R428-Pad1_ 0R
D427 Net-_D424-Pad2_ Net-_D426-Pad1_ LL4148
D426 Net-_D426-Pad1_ Net-_D424-Pad2_ LL4148
R438 Net-_D424-Pad2_ Net-_C407-Pad1_ 15k
D424 Net-_D420-Pad1_ Net-_D424-Pad2_ LL4148
D425 Net-_D424-Pad2_ Net-_D420-Pad1_ LL4148
R434 Net-_D420-Pad1_ Net-_C406-Pad2_ 15k
D421 Net-_D418-Pad2_ Net-_D420-Pad1_ LL4148
D420 Net-_D420-Pad1_ Net-_D418-Pad2_ LL4148
R431 Net-_D418-Pad2_ Net-_C407-Pad1_ 15k
D418 Net-_D414-Pad1_ Net-_D418-Pad2_ LL4148
D419 Net-_D418-Pad2_ Net-_D414-Pad1_ LL4148
R429 Net-_D414-Pad1_ Net-_C406-Pad2_ 15k
D415 Net-_D412-Pad2_ Net-_D414-Pad1_ LL4148
D414 Net-_D414-Pad1_ Net-_D412-Pad2_ LL4148
R427 Net-_D412-Pad2_ Net-_C407-Pad1_ 15k
D412 Net-_C407-Pad2_ Net-_D412-Pad2_ LL4148
D413 Net-_D412-Pad2_ Net-_C407-Pad2_ LL4148
R424 Net-_C407-Pad2_ Net-_C406-Pad2_ 15k
D411 Net-_C406-Pad1_ Net-_C407-Pad2_ LL4148
D410 Net-_C407-Pad2_ Net-_C406-Pad1_ LL4148
R419 Net-_C406-Pad1_ Net-_C407-Pad1_ 15k
D408 Net-_D408-Pad1_ Net-_C406-Pad1_ LL4148
D409 Net-_C406-Pad1_ Net-_D408-Pad1_ LL4148
R416 Net-_D408-Pad1_ Net-_C406-Pad2_ 15k
C406 Net-_C406-Pad1_ Net-_C406-Pad2_ 10n opt
C407 Net-_C407-Pad1_ Net-_C407-Pad2_ 10n opt
R411 Net-_R406-Pad2_ Net-_C407-Pad1_ 5k6
R406 Net-_C406-Pad2_ Net-_R406-Pad2_ 5k6
R428 Net-_R428-Pad1_ Net-_C406-Pad2_ 27k
D417 Net-_C407-Pad1_ Net-_D416-Pad1_ LL4148
D416 Net-_D416-Pad1_ Net-_C407-Pad1_ LL4148
R426 Net-_C407-Pad1_ Net-_D416-Pad1_ 56k
R433 Net-_D416-Pad1_ Net-_R430-Pad1_ 5k6
R430 Net-_R430-Pad1_ Net-_C408-Pad1_ 56k
.end
