.title KiCad schematic
P9 GND +5VD +5V +12V +15V CONN_5
P13 GND GND GND GND GND GND CONN_6
P7 /CONNECTEURS/M1A /CONNECTEURS/M1B /CONNECTEURS/M2A /CONNECTEURS/M2B /CONNECTEURS/M3A /CONNECTEURS/M3B /CONNECTEURS/M4A /CONNECTEURS/M4B /CONNECTEURS/M5A /CONNECTEURS/M5B /CONNECTEURS/M6A /CONNECTEURS/M6B CONN_12
P8 GND GND /CONNECTEURS/SDA /CONNECTEURS/SCL /CONNECTEURS/RX /CONNECTEURS/TX NC_01 NC_02 /CONNECTEURS/IO0 /CONNECTEURS/IO1 /CONNECTEURS/IO2 /CONNECTEURS/IO3 /CONNECTEURS/IO4 /CONNECTEURS/IO5 /CONNECTEURS/IO6 /CONNECTEURS/IO7 NC_03 NC_04 GND NC_05 /CONNECTEURS/SERV1 GND /CONNECTEURS/SERV2 GND /CONNECTEURS/SERV3 GND /CONNECTEURS/SERV4 NC_06 /CONNECTEURS/SERV5 GND /CONNECTEURS/SERV6 NC_07 /CONNECTEURS/A1 /CONNECTEURS/A2 /CONNECTEURS/B1 /CONNECTEURS/B2 /CONNECTEURS/Z1 /CONNECTEURS/Z2 GND GND HE10-40
P12 /CONNECTEURS/SERV1 /CONNECTEURS/SERV2 /CONNECTEURS/SERV3 /CONNECTEURS/SERV4 /CONNECTEURS/SERV5 /CONNECTEURS/SERV6 CONN_6
P11 /CONNECTEURS/IO0 /CONNECTEURS/IO1 /CONNECTEURS/IO2 /CONNECTEURS/IO3 /CONNECTEURS/IO4 /CONNECTEURS/IO5 /CONNECTEURS/IO6 /CONNECTEURS/IO7 CONN_8
P10 /CONNECTEURS/A1 /CONNECTEURS/B1 /CONNECTEURS/Z1 /CONNECTEURS/A2 /CONNECTEURS/B2 /CONNECTEURS/Z2 GND +15V CONN_8
P18 /CONNECTEURS/M5A /CONNECTEURS/M5B /CONNECTEURS/M6A /CONNECTEURS/M6B CONN_4
P17 /CONNECTEURS/M3A /CONNECTEURS/M3B /CONNECTEURS/M4A /CONNECTEURS/M4B CONN_4
P15 GND /CONNECTEURS/TX +5VD /CONNECTEURS/RX CONN_4
P16 /CONNECTEURS/M1A /CONNECTEURS/M1B /CONNECTEURS/M2A /CONNECTEURS/M2B CONN_4
P14 GND +5VD /CONNECTEURS/SCL /CONNECTEURS/SDA CONN_4
P5 GND +5VD +5V +12V +15V CONN_5
P4 GND +5VD +5V +12V +15V CONN_5
P3 GND +5VD +5V +12V +15V CONN_5
P1 GND +5VD +5V +12V +15V CONN_5
P2 GND +5VD +5V +12V +15V CONN_5
D5 +12V Net-_D5-Pad2_ LED
D4 +3.3V Net-_D4-Pad2_ LED
D3 +5VD Net-_D3-Pad2_ LED
D1 +BATT Net-_D1-Pad2_ LED
D2 +15V Net-_D2-Pad2_ LED
R1 GND Net-_D1-Pad2_ R
R2 GND Net-_D2-Pad2_ R
R5 Net-_D5-Pad2_ GND R
R4 Net-_D4-Pad2_ GND R
R3 Net-_D3-Pad2_ GND R
K7 GND +5VD CONN_2
K2 +15V +BATT CONN_2
K1 +BATT GND CONN_2
K15 GND +12V CONN_2
K14 GND +12V CONN_2
K13 GND +12V CONN_2
K12 GND +12V CONN_2
K11 GND +12V CONN_2
K10 GND +12V CONN_2
U3 +15V GND NC_08 +12V GND NC_09 TRACO-25-1212
K9 GND +3.3V CONN_2
K8 GND +3.3V CONN_2
K6 GND +5VD CONN_2
K5 GND +5VD CONN_2
K4 GND +5VD CONN_2
K3 GND +5VD CONN_2
C1 +3.3V GND 10u/10V
U1 GND +5VD +3.3V LM1086-3.3
U2 +15V GND NC_10 +5VD GND NC_11 TRACO-25-1211
.end
