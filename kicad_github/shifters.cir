.title KiCad schematic
U17 NC_01 NC_02 +5V /DAC2 /COMP1 /COMP1 /COMP2 /DAC3 /COMP1 NC_03 /COMP2 GND NC_04 NC_05 LM339
C1 +5V GND 0.1uF
J1 /A1 /A2 /A3 /A4 /A5 /A6 /A7 /A8 /VCCA GND Conn_02x05_Odd_Even
J2 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 GND Conn_02x05_Odd_Even
U1 /DAC2 /COMP1 /A1 /COMP2 /DAC3 NC_15 GND GND NC_16 NC_17 NC_18 /ADC Net-_R1-Pad1_ Net-_R5-Pad1_ Net-_U1-Pad15_ +5V 74HC4051
R1 Net-_R1-Pad1_ GND R
R5 Net-_R5-Pad1_ /VCCA R
U5 +1V2 GND NC_19 Net-_U1-Pad15_ NC_20 /VCCA SHIFTER1
R17 /gf_adc /ADC 5k
R18 GND /gf_adc 10k
U2 /DAC2 /COMP1 /A2 /COMP2 /DAC3 NC_21 GND GND NC_22 NC_23 NC_24 /ADC Net-_R2-Pad1_ Net-_R6-Pad1_ Net-_U2-Pad15_ +5V 74HC4051
R2 Net-_R2-Pad1_ GND R
R6 Net-_R6-Pad1_ /VCCA R
U6 +1V2 GND NC_25 Net-_U2-Pad15_ NC_26 /VCCA SHIFTER2
U3 /DAC2 /COMP1 /A3 /COMP2 /DAC3 NC_27 GND GND NC_28 NC_29 NC_30 /ADC Net-_R3-Pad1_ Net-_R7-Pad1_ Net-_U3-Pad15_ +5V 74HC4051
R3 Net-_R3-Pad1_ GND R
R7 Net-_R7-Pad1_ /VCCA R
U7 +1V2 GND NC_31 Net-_U3-Pad15_ NC_32 /VCCA SHIFTER3
U4 /DAC2 /COMP1 /A4 /COMP2 /DAC3 NC_33 GND GND NC_34 NC_35 NC_36 /ADC Net-_R4-Pad1_ Net-_R8-Pad1_ Net-_U4-Pad15_ +5V 74HC4051
R4 Net-_R4-Pad1_ GND R
R8 Net-_R8-Pad1_ /VCCA R
U8 +1V2 GND NC_37 Net-_U4-Pad15_ NC_38 /VCCA SHIFTER4
U9 /DAC2 /COMP1 /A5 /COMP2 /DAC3 NC_39 GND GND NC_40 NC_41 NC_42 /ADC Net-_R9-Pad1_ Net-_R13-Pad1_ Net-_U13-Pad4_ +5V 74HC4051
R9 Net-_R9-Pad1_ GND R
R13 Net-_R13-Pad1_ /VCCA R
U13 +1V2 GND NC_43 Net-_U13-Pad4_ NC_44 /VCCA SHIFTER5
U10 /DAC2 /COMP1 /A6 /COMP2 /DAC3 NC_45 GND GND NC_46 NC_47 NC_48 /ADC Net-_R10-Pad1_ Net-_R14-Pad1_ Net-_U10-Pad15_ +5V 74HC4051
R10 Net-_R10-Pad1_ GND R
R14 Net-_R14-Pad1_ /VCCA R
U14 +1V2 GND NC_49 Net-_U10-Pad15_ NC_50 /VCCA SHIFTER6
U11 /DAC2 /COMP1 /A7 /COMP2 /DAC3 NC_51 GND GND NC_52 NC_53 NC_54 /ADC Net-_R11-Pad1_ Net-_R15-Pad1_ Net-_U11-Pad15_ +5V 74HC4051
R11 Net-_R11-Pad1_ GND R
R15 Net-_R15-Pad1_ /VCCA R
U15 +1V2 GND NC_55 Net-_U11-Pad15_ NC_56 /VCCA SHIFTER7
U12 /DAC2 /COMP1 /A8 /COMP2 /DAC3 NC_57 GND GND NC_58 NC_59 NC_60 /ADC Net-_R12-Pad1_ Net-_R16-Pad1_ Net-_U12-Pad15_ +5V 74HC4051
R12 Net-_R12-Pad1_ GND R
R16 Net-_R16-Pad1_ /VCCA R
U16 +1V2 GND NC_61 Net-_U12-Pad15_ NC_62 /VCCA SHIFTER8
.end
