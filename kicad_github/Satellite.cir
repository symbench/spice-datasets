.title KiCad schematic
U1 /RESET /COL11 /COL10 /USB_D+ /USB_D- /COL9 +5V GND Net-_C2-Pad1_ Net-_C1-Pad2_ /COL8 /COL7 /COL6 /ROW0 /ROW1 /ROW2 /ROW3 /COL5 /COL4 +5V NC_01 GND /COL3 /COL2 /COL1 /COL0 /i2c_SDA /i2c_SCL ATmega328P-PU
R4 +5V /RESET 10k
J2 /COL5 +5V /COL4 /ROW3 /RESET GND AVR-ISP-6
J1 Net-_F1-Pad2_ Net-_D50-Pad1_ Net-_D49-Pad1_ NC_02 GND NC_03 USB
F1 +5V Net-_F1-Pad2_ 100mA
R2 Net-_D50-Pad1_ /USB_D- 68
R1 +5V Net-_D50-Pad1_ 1.5k
C3 +5V GND 4.7u
C4 +5V GND 100n
C5 +5V GND 100n
D49 Net-_D49-Pad1_ GND 3.6V
D50 Net-_D50-Pad1_ GND 3.6V
R3 /USB_D+ Net-_D49-Pad1_ 68
Y1 Net-_C2-Pad1_ Net-_C1-Pad2_ 16Mhz
J3 +5V /i2c_SCL /i2c_SDA GND I2C_Connector
R6 +5V /i2c_SDA I2C
SW49 GND /RESET RESET
SW50 GND /COL8 BOOT
R8 Net-_LED1-Pad2_ /i2c_SDA 1.5k
R7 Net-_LED2-Pad2_ /i2c_SCL 1.5k
LED2 GND Net-_LED2-Pad2_ RED
LED1 GND Net-_LED1-Pad2_ Green
R5 +5V /i2c_SCL I2C
D48 /ROW3 Net-_D48-Pad2_ 1N4148
D47 /ROW3 Net-_D47-Pad2_ 1N4148
D46 /ROW3 Net-_D46-Pad2_ 1N4148
D45 /ROW3 Net-_D45-Pad2_ 1N4148
D44 /ROW3 Net-_D44-Pad2_ 1N4148
D43 /ROW3 Net-_D43-Pad2_ 1N4148
SW48 Net-_D48-Pad2_ /COL5 SW_Push
SW47 Net-_D47-Pad2_ /COL4 SW_Push
SW46 Net-_D46-Pad2_ /COL3 SW_Push
SW45 Net-_D45-Pad2_ /COL2 SW_Push
SW44 Net-_D44-Pad2_ /COL1 SW_Push
SW43 Net-_D43-Pad2_ /COL0 SW_Push
D42 /ROW3 Net-_D42-Pad2_ 1N4148
D41 /ROW3 Net-_D41-Pad2_ 1N4148
D40 /ROW3 Net-_D40-Pad2_ 1N4148
D39 /ROW3 Net-_D39-Pad2_ 1N4148
D38 /ROW3 Net-_D38-Pad2_ 1N4148
D37 /ROW3 Net-_D37-Pad2_ 1N4148
SW42 Net-_D42-Pad2_ /COL11 SW_Push
SW41 Net-_D41-Pad2_ /COL10 SW_Push
SW40 Net-_D40-Pad2_ /COL9 SW_Push
SW39 Net-_D39-Pad2_ /COL8 SW_Push
SW38 Net-_D38-Pad2_ /COL7 SW_Push
SW37 Net-_D37-Pad2_ /COL6 SW_Push
D36 /ROW2 Net-_D36-Pad2_ 1N4148
D35 /ROW2 Net-_D35-Pad2_ 1N4148
D34 /ROW2 Net-_D34-Pad2_ 1N4148
D33 /ROW2 Net-_D33-Pad2_ 1N4148
D32 /ROW2 Net-_D32-Pad2_ 1N4148
D31 /ROW2 Net-_D31-Pad2_ 1N4148
SW36 Net-_D36-Pad2_ /COL5 SW_Push
SW35 Net-_D35-Pad2_ /COL4 SW_Push
SW34 Net-_D34-Pad2_ /COL3 SW_Push
SW33 Net-_D33-Pad2_ /COL2 SW_Push
SW32 Net-_D32-Pad2_ /COL1 SW_Push
SW31 Net-_D31-Pad2_ /COL0 SW_Push
D30 /ROW2 Net-_D30-Pad2_ 1N4148
D29 /ROW2 Net-_D29-Pad2_ 1N4148
D28 /ROW2 Net-_D28-Pad2_ 1N4148
D27 /ROW2 Net-_D27-Pad2_ 1N4148
D26 /ROW2 Net-_D26-Pad2_ 1N4148
D25 /ROW2 Net-_D25-Pad2_ 1N4148
SW30 Net-_D30-Pad2_ /COL11 SW_Push
SW29 Net-_D29-Pad2_ /COL10 SW_Push
SW28 Net-_D28-Pad2_ /COL9 SW_Push
SW27 Net-_D27-Pad2_ /COL8 SW_Push
SW26 Net-_D26-Pad2_ /COL7 SW_Push
SW25 Net-_D25-Pad2_ /COL6 SW_Push
D24 /ROW1 Net-_D24-Pad2_ 1N4148
D23 /ROW1 Net-_D23-Pad2_ 1N4148
D22 /ROW1 Net-_D22-Pad2_ 1N4148
D21 /ROW1 Net-_D21-Pad2_ 1N4148
D20 /ROW1 Net-_D20-Pad2_ 1N4148
D19 /ROW1 Net-_D19-Pad2_ 1N4148
SW24 Net-_D24-Pad2_ /COL5 SW_Push
SW23 Net-_D23-Pad2_ /COL4 SW_Push
SW22 Net-_D22-Pad2_ /COL3 SW_Push
SW21 Net-_D21-Pad2_ /COL2 SW_Push
SW20 Net-_D20-Pad2_ /COL1 SW_Push
SW19 Net-_D19-Pad2_ /COL0 SW_Push
D18 /ROW1 Net-_D18-Pad2_ 1N4148
D17 /ROW1 Net-_D17-Pad2_ 1N4148
D16 /ROW1 Net-_D16-Pad2_ 1N4148
D15 /ROW1 Net-_D15-Pad2_ 1N4148
D14 /ROW1 Net-_D14-Pad2_ 1N4148
D13 /ROW1 Net-_D13-Pad2_ 1N4148
SW18 Net-_D18-Pad2_ /COL11 SW_Push
SW17 Net-_D17-Pad2_ /COL10 SW_Push
SW16 Net-_D16-Pad2_ /COL9 SW_Push
SW15 Net-_D15-Pad2_ /COL8 SW_Push
SW14 Net-_D14-Pad2_ /COL7 SW_Push
SW13 Net-_D13-Pad2_ /COL6 SW_Push
D12 /ROW0 Net-_D12-Pad2_ 1N4148
D11 /ROW0 Net-_D11-Pad2_ 1N4148
D10 /ROW0 Net-_D10-Pad2_ 1N4148
D9 /ROW0 Net-_D9-Pad2_ 1N4148
D8 /ROW0 Net-_D8-Pad2_ 1N4148
SW12 Net-_D12-Pad2_ /COL5 SW_Push
SW11 Net-_D11-Pad2_ /COL4 SW_Push
SW10 Net-_D10-Pad2_ /COL3 SW_Push
SW9 Net-_D9-Pad2_ /COL2 SW_Push
SW8 Net-_D8-Pad2_ /COL1 SW_Push
D5 /ROW0 Net-_D5-Pad2_ 1N4148
D4 /ROW0 Net-_D4-Pad2_ 1N4148
D3 /ROW0 Net-_D3-Pad2_ 1N4148
SW5 Net-_D5-Pad2_ /COL10 SW_Push
SW4 Net-_D4-Pad2_ /COL9 SW_Push
SW3 Net-_D3-Pad2_ /COL8 SW_Push
SW2 Net-_D2-Pad2_ /COL7 SW_Push
SW1 Net-_D1-Pad2_ /COL6 SW_Push
D2 /ROW0 Net-_D2-Pad2_ 1N4148
D1 /ROW0 Net-_D1-Pad2_ 1N4148
SW6 Net-_D6-Pad2_ /COL11 SW_Push
D6 /ROW0 Net-_D6-Pad2_ 1N4148
SW7 Net-_D7-Pad2_ /COL0 SW_Push
D7 /ROW0 Net-_D7-Pad2_ 1N4148
C1 GND Net-_C1-Pad2_ 22p
C2 Net-_C2-Pad1_ GND 22p
.end
