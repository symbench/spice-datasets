.title KiCad schematic
U1 /D4 /D3 /D2 /D1 /D0 /AS /UDS /LDS /RW /DTACK /BG /BGACK /BR VCC /CLK GND /HALT /RESET /VMA /E /VPA /BERR /IPL2 /IPL1 /IPL0 /FC2 /FC1 /FC0 /A0 /A1 /A2 /A3 /A4 /A5 /A6 /A7 /A8 /A9 /A10 /A11 /A12 /A13 /A14 /A15 /A16 /A17 /A18 /A19 VCC /A20 /A21 /A22 GND /D15 /D14 /D13 /D12 /D11 /D10 /D9 /D8 /D7 /D6 /D5 68000D
U2 NC_01 NC_02 NC_03 /A18 NC_04 NC_05 NC_06 GND /A6 NC_07 /A7 NC_08 NC_09 NC_10 NC_11 +3V3 NC_12 +5V GND GND NC_13 GND NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 /BGACK NC_23 /AS NC_24 NC_25 NC_26 NC_27 /A20 /A19 /A21 /HALT /A22 /FC0 NC_28 /D2 /D3 /D4 GND /D5 /A1 /A2 /A0 /A8 /A17 /A9 /A16 NC_29 /RESET GND /D1 /D6 /VPA Net-_R3-Pad2_ NC_30 /E NC_31 NC_32 NC_33 NC_34 GND GND NC_35 NC_36 /I2C_SCL NC_37 /I2C_SDA NC_38 NC_39 NC_40 GND NC_41 /BR NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 GND NC_50 /UDS NC_51 /LDS NC_52 NC_53 /CLK NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 /RW /A5 /BG /A4 GND Net-_U2-Pad112_ /IPL0 /A10 /BERR Net-_U2-Pad116_ /DTACK /IPL1 /D10 /IPL2 /D12 /A14 /D14 Net-_U2-Pad124_ /D15 GND /D13 /D11 /A13 /A3 /A12 /A15 NC_61 /A11 GND /D0 NC_62 /VMA NC_63 /FC2 /FC1 NC_64 GND GND NUCLEO144-F746ZG
J1 +5V Net-_J1-Pad2_ +3V3 VSel
J2 Net-_J1-Pad2_ VCC Current Sense
U3 VCC /D9 /D8 /D7 Net-_R5-Pad2_ NC_65 GND Net-_R3-Pad2_ NC_66 Net-_R7-Pad2_ Net-_U2-Pad116_ Net-_U2-Pad112_ Net-_U2-Pad124_ +3V3 TXB0104D
C1 VCC GND 100nF
C2 VCC GND 100nF
C3 VCC GND 100nF
C4 +3V3 GND 100nF
R3 +3V3 Net-_R3-Pad2_ 10k
R4 Net-_R3-Pad2_ GND 10k
R1 VCC /RESET 10k
R2 /RESET GND 10k
J3 +3V3 /I2C_SDA /I2C_SCL GND Conn_01x04
R7 +3V3 Net-_R7-Pad2_ R
R8 Net-_R7-Pad2_ GND R
R6 Net-_R5-Pad2_ GND R
R5 VCC Net-_R5-Pad2_ R
.end
