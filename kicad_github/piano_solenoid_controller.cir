.title KiCad schematic
U1 I6 I5 I4 I3 I2 I1 I0 GND DOUT RST CLK LATCH OE DIN I7 VCC 74HC595
R3 GND OE 10K
C1 VDD GNDPWR 100n
C2 VDD GNDPWR 10u
C3 VCC GND 100n
J14 VDD O7 OC7
D10 O7 GNDPWR 1N4148
R90 Net-_Q9-Pad1_ T7 47R
D18 VDD O7 1N4007
R40 Net-_R39-Pad2_ I7 NC
R41 I7 Net-_R41-Pad2_ 1K
R39 VCC Net-_R39-Pad2_ 47R
R42 Net-_R41-Pad2_ GND NC
R98 Net-_Q9-Pad1_ GNDPWR 10K
D2 Net-_D2-Pad1_ VCC LED
R6 Net-_D2-Pad1_ GND 1K
C4 VCC GND 100n
D1 Net-_D1-Pad1_ VDD LED
R5 Net-_D1-Pad1_ GNDPWR 10K
J3 GND VCC VCC_I
J4 VCC GND VCC_O
U2 Net-_R9-Pad1_ CLK GND CLKO VCC 74AHC1G125
R9 Net-_R9-Pad1_ GND 47R
R10 CLK CLKO NC
R4 Net-_J1-Pad6_ RST 47R
R2 VCC RST 10K
R1 OE Net-_J1-Pad3_ 47R
R81 Net-_R50-Pad2_ Net-_Q8-Pad1_ 1K
R82 GNDPWR Net-_R58-Pad1_ 1K
R58 Net-_R58-Pad1_ T7 NC
J5 GNDPWR VDD VDD_I
J6 VDD GNDPWR VDD_O
R50 VDD Net-_R50-Pad2_ NC
U10 Net-_R39-Pad2_ Net-_R41-Pad2_ Net-_R58-Pad1_ Net-_R50-Pad2_ PC817
J13 VDD O6 OC6
D9 O6 GNDPWR 1N4148
R89 Net-_Q16-Pad1_ T6 47R
D17 VDD O6 1N4007
R36 Net-_R35-Pad2_ I6 NC
R37 I6 Net-_R37-Pad2_ 1K
R35 VCC Net-_R35-Pad2_ 47R
R38 Net-_R37-Pad2_ GND NC
R97 Net-_Q16-Pad1_ GNDPWR 10K
R78 Net-_R49-Pad2_ Net-_Q7-Pad1_ 1K
R79 GNDPWR Net-_R57-Pad1_ 1K
R57 Net-_R57-Pad1_ T6 NC
R49 VDD Net-_R49-Pad2_ NC
U9 Net-_R35-Pad2_ Net-_R37-Pad2_ Net-_R57-Pad1_ Net-_R49-Pad2_ PC817
J12 VDD O5 OC5
D8 O5 GNDPWR 1N4148
R88 Net-_Q15-Pad1_ T5 47R
D16 VDD O5 1N4007
R32 Net-_R31-Pad2_ I5 NC
R33 I5 Net-_R33-Pad2_ 1K
R31 VCC Net-_R31-Pad2_ 47R
R34 Net-_R33-Pad2_ GND NC
R96 Net-_Q15-Pad1_ GNDPWR 10K
R75 Net-_R48-Pad2_ Net-_Q6-Pad1_ 1K
R76 GNDPWR Net-_R56-Pad1_ 1K
R56 Net-_R56-Pad1_ T5 NC
R48 VDD Net-_R48-Pad2_ NC
U8 Net-_R31-Pad2_ Net-_R33-Pad2_ Net-_R56-Pad1_ Net-_R48-Pad2_ PC817
J11 VDD O4 OC4
D7 O4 GNDPWR 1N4148
R87 Net-_Q14-Pad1_ T4 47R
D15 VDD O4 1N4007
R28 Net-_R27-Pad2_ I4 NC
R29 I4 Net-_R29-Pad2_ 1K
R27 VCC Net-_R27-Pad2_ 47R
R30 Net-_R29-Pad2_ GND NC
R95 Net-_Q14-Pad1_ GNDPWR 10K
R72 Net-_R47-Pad2_ Net-_Q5-Pad1_ 1K
R73 GNDPWR Net-_R55-Pad1_ 1K
R55 Net-_R55-Pad1_ T4 NC
R47 VDD Net-_R47-Pad2_ NC
U7 Net-_R27-Pad2_ Net-_R29-Pad2_ Net-_R55-Pad1_ Net-_R47-Pad2_ PC817
J10 VDD O3 OC3
D6 O3 GNDPWR 1N4148
R86 Net-_Q13-Pad1_ T3 47R
D14 VDD O3 1N4007
R24 Net-_R23-Pad2_ I3 NC
R25 I3 Net-_R25-Pad2_ 1K
R23 VCC Net-_R23-Pad2_ 47R
R26 Net-_R25-Pad2_ GND NC
R94 Net-_Q13-Pad1_ GNDPWR 10K
R69 Net-_R46-Pad2_ Net-_Q4-Pad1_ 1K
R70 GNDPWR Net-_R54-Pad1_ 1K
R54 Net-_R54-Pad1_ T3 NC
R46 VDD Net-_R46-Pad2_ NC
U6 Net-_R23-Pad2_ Net-_R25-Pad2_ Net-_R54-Pad1_ Net-_R46-Pad2_ PC817
J9 VDD O2 OC2
D5 O2 GNDPWR 1N4148
R85 Net-_Q12-Pad1_ T2 47R
D13 VDD O2 1N4007
R20 Net-_R19-Pad2_ I2 NC
R21 I2 Net-_R21-Pad2_ 1K
R19 VCC Net-_R19-Pad2_ 47R
R22 Net-_R21-Pad2_ GND NC
R93 Net-_Q12-Pad1_ GNDPWR 10K
R66 Net-_R45-Pad2_ Net-_Q3-Pad1_ 1K
R67 GNDPWR Net-_R53-Pad1_ 1K
R53 Net-_R53-Pad1_ T2 NC
R45 VDD Net-_R45-Pad2_ NC
U5 Net-_R19-Pad2_ Net-_R21-Pad2_ Net-_R53-Pad1_ Net-_R45-Pad2_ PC817
J8 VDD O1 OC1
D4 O1 GNDPWR 1N4148
R84 Net-_Q11-Pad1_ T1 47R
D12 VDD O1 1N4007
R16 Net-_R15-Pad2_ I1 NC
R17 I1 Net-_R17-Pad2_ 1K
R15 VCC Net-_R15-Pad2_ 47R
R18 Net-_R17-Pad2_ GND NC
R92 Net-_Q11-Pad1_ GNDPWR 10K
R63 Net-_R44-Pad2_ Net-_Q2-Pad1_ 1K
R64 GNDPWR Net-_R52-Pad1_ 1K
R52 Net-_R52-Pad1_ T1 NC
R44 VDD Net-_R44-Pad2_ NC
U4 Net-_R15-Pad2_ Net-_R17-Pad2_ Net-_R52-Pad1_ Net-_R44-Pad2_ PC817
J7 VDD O0 OC0
D3 O0 GNDPWR 1N4148
R83 Net-_Q10-Pad1_ T0 47R
D11 VDD O0 1N4007
R12 Net-_R11-Pad2_ I0 NC
R13 I0 Net-_R13-Pad2_ 1K
R11 VCC Net-_R11-Pad2_ 47R
R14 Net-_R13-Pad2_ GND NC
R91 Net-_Q10-Pad1_ GNDPWR 10K
R60 Net-_R43-Pad2_ Net-_Q1-Pad1_ 1K
R61 GNDPWR Net-_R51-Pad1_ 1K
R51 Net-_R51-Pad1_ T0 NC
R43 VDD Net-_R43-Pad2_ NC
U3 Net-_R11-Pad2_ Net-_R13-Pad2_ Net-_R51-Pad1_ Net-_R43-Pad2_ PC817
Q8 Net-_Q8-Pad1_ T7 VDD BC857
Q7 Net-_Q7-Pad1_ T6 VDD BC857
Q6 Net-_Q6-Pad1_ T5 VDD BC857
Q5 Net-_Q5-Pad1_ T4 VDD BC857
Q4 Net-_Q4-Pad1_ T3 VDD BC857
Q3 Net-_Q3-Pad1_ T2 VDD BC857
Q2 Net-_Q2-Pad1_ T1 VDD BC857
Q1 Net-_Q1-Pad1_ T0 VDD BC857
R59 Net-_R43-Pad2_ GNDPWR 10K
R62 Net-_R44-Pad2_ GNDPWR 10K
R65 Net-_R45-Pad2_ GNDPWR 10K
R68 Net-_R46-Pad2_ GNDPWR 10K
R71 Net-_R47-Pad2_ GNDPWR 10K
R74 Net-_R48-Pad2_ GNDPWR 10K
R77 Net-_R49-Pad2_ GNDPWR 10K
R80 Net-_R50-Pad2_ GNDPWR 10K
D19 O7 Net-_D19-Pad2_ LED
R99 Net-_D19-Pad2_ VDD 10K
D26 O6 Net-_D26-Pad2_ LED
R106 Net-_D26-Pad2_ VDD 10K
D25 O5 Net-_D25-Pad2_ LED
R105 Net-_D25-Pad2_ VDD 10K
D24 O4 Net-_D24-Pad2_ LED
R104 Net-_D24-Pad2_ VDD 10K
D23 O3 Net-_D23-Pad2_ LED
R103 Net-_D23-Pad2_ VDD 10K
D22 O2 Net-_D22-Pad2_ LED
R102 Net-_D22-Pad2_ VDD 10K
D21 O1 Net-_D21-Pad2_ LED
R101 Net-_D21-Pad2_ VDD 10K
D20 O0 Net-_D20-Pad2_ LED
R100 Net-_D20-Pad2_ VDD 10K
Q10 Net-_Q10-Pad1_ O0 GNDPWR Q_NMOS_GDS
Q11 Net-_Q11-Pad1_ O1 GNDPWR Q_NMOS_GDS
Q12 Net-_Q12-Pad1_ O2 GNDPWR Q_NMOS_GDS
Q13 Net-_Q13-Pad1_ O3 GNDPWR Q_NMOS_GDS
Q14 Net-_Q14-Pad1_ O4 GNDPWR Q_NMOS_GDS
Q15 Net-_Q15-Pad1_ O5 GNDPWR Q_NMOS_GDS
Q16 Net-_Q16-Pad1_ O6 GNDPWR Q_NMOS_GDS
Q9 Net-_Q9-Pad1_ O7 GNDPWR Q_NMOS_GDS
J1 VCC DIN Net-_J1-Pad3_ LATCH GND Net-_J1-Pad6_ GND CLK GND DIN
R8 Net-_J2-Pad6_ RST 47R
R7 OE Net-_J2-Pad3_ 47R
J2 VCC DOUT Net-_J2-Pad3_ LATCH GND Net-_J2-Pad6_ GND CLKO GND DOUT
C5 VDD GNDPWR 10u
C6 VCC GND 100n
C7 VCC GND 100n
.end
