.title KiCad schematic
J1 +3V3 +5V /Raspberry Pi/GPIO2 +5V /Raspberry Pi/GPIO3 GND GPIO4 GPIO14 GND GPIO15 GPIO17 GPIO18 GPIO27 GND GPIO22 GPIO23 +3V3 GPIO24 GPIO10 GND GPIO9 GPIO25 GPIO11 GPIO8 GND GPIO7 NC_01 NC_02 GPIO5 GND GPIO6 GPIO12 GPIO13 GND GPIO19 GPIO16 GPIO26 GPIO20 GND GPIO21 RasPi
C1 +5V GND 220u/10V
U1 GPB0 GPB1 GPB2 GPB3 GPB4 GPB5 GPB6 GPB7 +3V3 GND NC_03 /Raspberry Pi/GPIO3 /Raspberry Pi/GPIO2 NC_04 NC_05 NC_06 NC_07 Net-_C2-Pad1_ NC_08 GPIO15 GPA0 GPA1 GPA2 GPA3 GPA4 GPA5 GPA6 GPA7 MCP23017_SO
C3 +3V3 GND 10u
C2 Net-_C2-Pad1_ GND 1n
R2 +3V3 Net-_C2-Pad1_ 100k
RN1 +3V3 GPA0 GPA1 GPA2 GPA3 GPA4 GPA5 GPA6 GPA7 10k
RN2 +3V3 GPB0 GPB1 GPB2 GPB3 GPB4 GPB5 GPB6 GPB7 10k
RN3 +3V3 GPIO21 GPIO26 GPIO20 GPIO19 GPIO16 GPIO13 GPIO12 GPIO6 10k
RN4 +3V3 GPIO5 GPIO7 GPIO11 GPIO8 GPIO9 GPIO25 GPIO10 GPIO24 10k
R3 +3V3 /Raspberry Pi/GPIO2 10k
R1 /Raspberry Pi/GPIO3 +3V3 10k
RN5 +3V3 GPIO22 GPIO23 GPIO27 GPIO18 GPIO17 GPIO15 GPIO14 GPIO4 10k
SW9 GND GPA0 SW_Push
SW8 GND GPA1 SW_Push
SW7 GND GPA2 SW_Push
SW6 GND GPA3 SW_Push
SW5 GND GPB4 SW_Push
SW4 GND GPB5 SW_Push
SW3 GND GPB6 SW_Push
SW2 GND GPB7 SW_Push
SW17 GND GPB0 SW_Push
SW16 GND GPB1 SW_Push
SW15 GND GPB2 SW_Push
SW14 GND GPB3 SW_Push
SW13 GND GPA4 SW_Push
SW12 GND GPA5 SW_Push
SW11 GND GPA6 SW_Push
SW10 GND GPA7 SW_Push
ENC2 GPIO20 GPIO26 GND GPIO21 GND Rotary_Encoder_Switch
ENC3 GPIO16 GPIO13 GND GPIO19 GND Rotary_Encoder_Switch
ENC4 GPIO7 GPIO8 GND GPIO12 GND Rotary_Encoder_Switch
ENC5 GPIO27 GPIO17 GND GPIO22 GND Rotary_Encoder_Switch
J2 +5V GPIO14 GPIO18 GND ENC1
J7 +3V3 +5V /Raspberry Pi/GPIO2 /Raspberry Pi/GPIO3 GPIO15 GND Conn_01x06
J8 GND GPIO18 +5V GPIO14 GND ENC1a
R4 Net-_C12-Pad1_ Net-_C4-Pad2_ 10k
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 1u
R5 Net-_C12-Pad1_ Net-_C4-Pad1_ 100k
C5 Net-_C12-Pad1_ Net-_C4-Pad1_ 100n
Q1 Net-_C4-Pad1_ +12V Net-_C12-Pad1_ FDD6685
Q2 Net-_C6-Pad2_ GND Net-_C4-Pad1_ 2N7002K
C7 Net-_C6-Pad2_ GND 100n
C6 +12V Net-_C6-Pad2_ 100n
R6 Net-_D1-Pad1_ Net-_C6-Pad2_ 180k
R7 +12V Net-_D1-Pad1_ 100k
D1 Net-_D1-Pad1_ NC_09 Net-_C4-Pad2_ BAS16J
SW1 GND Net-_C4-Pad2_ ON_OFF
C10 +12V GND 10u
C12 Net-_C12-Pad1_ GND 10u
L1 Net-_C12-Pad1_ Net-_C16-Pad1_ 74279226101
C16 Net-_C16-Pad1_ GND 22u/35V
D2 Net-_C16-Pad1_ GND SK54
F1 Net-_C16-Pad1_ Net-_C19-Pad1_ 5A
C19 Net-_C19-Pad1_ GND 100n
C21 Net-_C19-Pad1_ GND 10u
J4 Net-_C19-Pad1_ GND 12V_IN
C11 +12V GND 100n
C13 +12V GND 1u
FB2 Net-_C15-Pad1_ +12V TBD
C15 Net-_C15-Pad1_ GND 100n
C17 Net-_C15-Pad1_ GND 1u
J3 Net-_C15-Pad1_ GND GND Net-_C15-Pad1_ 12V_SWITCHED
FB1 Net-_C8-Pad1_ +12V TBD
C8 Net-_C8-Pad1_ GND 47u/35V
C9 Net-_C8-Pad1_ GND 100n
U2 Net-_C8-Pad1_ Net-_R8-Pad2_ NC_10 GND Net-_R10-Pad1_ Net-_C14-Pad1_ Net-_C18-Pad1_ GND LMZ22005
R8 GND Net-_R8-Pad2_ 1k5
R9 GND Net-_R10-Pad1_ 620
C14 Net-_C14-Pad1_ GND 100n
R10 Net-_R10-Pad1_ Net-_R10-Pad2_ 3k3
R11 Net-_R10-Pad2_ Net-_C18-Pad1_ 47
C18 Net-_C18-Pad1_ GND 100n
C20 Net-_C18-Pad1_ GND 10u
C22 Net-_C18-Pad1_ GND 100u/10V
FB3 Net-_C18-Pad1_ +5V TBD
C23 +5V GND 100n
C24 +5V GND 10u
C25 +5V GND 100u/10V
C26 +5V GND 10u
C27 +5V GND 100u/6.3V
J5 +5V GND +5V 5V/3A
R12 Net-_D3-Pad2_ +5V 1k5
D3 GND Net-_D3-Pad2_ Green
J6 +5V NC_11 NC_12 NC_13 GND TO_DISPLAY
.end
