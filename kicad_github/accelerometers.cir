.title KiCad schematic
J1 Net-_C2-Pad2_ Net-_C3-Pad2_ Net-_C4-Pad1_ NC_01 GND GND USB-Mini
U2 +3V3 /RXD GND NC_02 /nTXLED Net-_R2-Pad2_ Net-_R1-Pad2_ +3V3 +3V3 +5V /nRXLED NC_03 GND NC_04 /TXD NC_05 GND TD230XQ
L1 +5V Net-_C2-Pad2_ IND
C2 GND Net-_C2-Pad2_ CAP_0603
C9 GND +5V CAP_0603
C10 GND +3V3 CAP_0603
R1 Net-_C3-Pad2_ Net-_R1-Pad2_ RES_0603
R2 Net-_C4-Pad1_ Net-_R2-Pad2_ RES_0603
C8 GND +3V3 CAP_0603
U1 Net-_R3-Pad1_ Net-_R5-Pad1_ +3V3 NC_06 Net-_R7-Pad1_ GND +3V3 GND GND +3V3 +3V3 Net-_R6-Pad1_ KXTJ3-1057
U3 Net-_R20-Pad1_ Net-_R22-Pad1_ /SA0 Net-_R24-Pad1_ NC_07 GND GND GND +3V3 +3V3 Net-_R11-Pad1_ Net-_R10-Pad1_ LIS2HH12
C5 GND +5V CAP_0603
C6 GND +5V CAP_0805
C4 Net-_C4-Pad1_ GND CAP_0603
C3 GND Net-_C3-Pad2_ CAP_0603
R16 /TXD /PIC_TX RES_0603
R17 /RXD /PIC_TX RES_0603
R18 /TXD /PIC_RX RES_0603
R19 /RXD /PIC_RX RES_0603
R13 /nRXLED Net-_D1-PadC_ RES_0603
R14 /nTXLED Net-_D2-PadC_ RES_0603
J2 /MCLR Net-_J2-Pad2_ GND /ICSPDAT /ICSPCLK NC_08 HEADER_1X6
R42 Net-_R42-Pad1_ /ICSPDAT RES_0603
R43 Net-_R43-Pad1_ /ICSPCLK RES_0603
R37 Net-_C14-Pad1_ +3V3 RES_0603
C13 GND +3V3 CAP_0603
C14 Net-_C14-Pad1_ GND CAP_0603
Q4 Net-_Q4-PadD_ Net-_Q4-PadG_ GND MOSFET-N
R35 Net-_D7-PadC_ Net-_Q4-PadD_ RES_0603
R33 Net-_D5-PadC_ Net-_Q3-PadD_ RES_0603
Q3 Net-_Q3-PadD_ Net-_Q3-PadG_ GND MOSFET-N
U4 +5V Net-_R15-Pad2_ GND Temp_SOT23-3
C12 GND +5V CAP_0603
R31 Net-_D4-PadC_ Net-_Q2-PadD_ RES_0603
Q2 Net-_Q2-PadD_ Net-_Q2-PadG_ GND MOSFET-N
D6 Net-_C14-Pad1_ /MCLR Schottky_SMA
R41 +3V3 Net-_J2-Pad2_ RES_0603
R15 /V_Temp Net-_R15-Pad2_ RES_0603
R12 /V_Temp GND RES_0603
D7 +3V3 Net-_D7-PadC_ LED_0603
D5 +3V3 Net-_D5-PadC_ LED_0603
D4 +3V3 Net-_D4-PadC_ LED_0603
M1 GND MNT-3MM
M2 GND MNT-3MM
M3 GND MNT-3MM
M4 GND MNT-3MM
R30 Net-_Q2-PadG_ /RC1 RES_0603
R32 Net-_Q3-PadG_ /RC2 RES_0603
R34 Net-_Q4-PadG_ /RC3 RES_0603
U5 +3V3 /RA5 /V_Temp /MCLR /PIC_RX /PIC_TX /RC3 /nSPI_CS /MOSI /SCL /SCLK /SDA /MISO /RC2 /RC1 /RC0 /RA2 Net-_R43-Pad1_ Net-_R42-Pad1_ GND PIC16F1829_SOIC
D1 +3V3 Net-_D1-PadC_ LED_0603
D2 +3V3 Net-_D2-PadC_ LED_0603
R29 Net-_D3-PadC_ Net-_Q1-PadD_ RES_0603
Q1 Net-_Q1-PadD_ Net-_Q1-PadG_ GND MOSFET-N
D3 +3V3 Net-_D3-PadC_ LED_0603
R28 Net-_Q1-PadG_ /RC0 RES_0603
R6 Net-_R6-Pad1_ /SCL RES_0603
R5 Net-_R5-Pad1_ /SDA RES_0603
R4 Net-_R3-Pad1_ GND RES_0603
R3 Net-_R3-Pad1_ +3V3 RES_0603
C1 GND +3V3 CAP_0603
C7 GND +3V3 CAP_0603
R7 Net-_R7-Pad1_ /RC0 RES_0603
R8 /SDA +3V3 RES_0603
R9 /SCL +3V3 RES_0603
R10 Net-_R10-Pad1_ /RC1 RES_0603
R11 Net-_R11-Pad1_ /RC2 RES_0603
C11 +3V3 GND CAP_0603
R23 /SA0 /MISO RES_0603
R22 Net-_R22-Pad1_ /nSPI_CS RES_0603
R21 Net-_R20-Pad1_ /SCL RES_0603
R20 Net-_R20-Pad1_ /SCLK RES_0603
R27 /SA0 GND RES_0603
R26 /SA0 +3V3 RES_0603
R25 Net-_R24-Pad1_ /SDA RES_0603
R24 Net-_R24-Pad1_ /MOSI RES_0603
Q5 Net-_Q5-PadD_ Net-_Q5-PadG_ GND MOSFET-N
R38 Net-_D8-PadC_ Net-_Q5-PadD_ RES_0603
R36 Net-_Q5-PadG_ /RA2 RES_0603
D8 +3V3 Net-_D8-PadC_ LED_0603
Q6 Net-_Q6-PadD_ Net-_Q6-PadG_ GND MOSFET-N
R40 Net-_D9-PadC_ Net-_Q6-PadD_ RES_0603
R39 Net-_Q6-PadG_ /RA5 RES_0603
D9 +3V3 Net-_D9-PadC_ LED_0603
.end
