.title KiCad schematic
R1 +3V3 Net-_C2-Pad1_ R_100
C2 Net-_C2-Pad1_ +3V3 C_100pF
Y1 Net-_C5-Pad1_ +3V3 Net-_C8-Pad1_ +3V3 Crystal_SMD
C5 Net-_C5-Pad1_ +3V3 C_30pF
C8 Net-_C8-Pad1_ +3V3 C_30pF
R6 +3V3 /RESET R_10K
U5 /CAN_TX +3V3 +3V3 /CAN_RX NC_01 /CAN_LO /CAN_HI +3V3 MCP2561-E_SN
C12 +3V3 +3V3 C_0.1uF
R12 /CAN_HI /CAN_LO R_200
J3 /MISO +3V3 /SCK /MOSI /RESET +3V3 CONN_02X03
C1 +3V3 +3V3 C_0.1uF
U6 /Rx /Tx NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 +3V3 +3V3 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 +3V3 +3V3 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 HC-05
U1 Net-_C4-Pad1_ /USBD- /USBD+ NC_29 +3V3 +3V3 USB_MicroB
U3 Net-_R4-Pad1_ NC_30 NC_31 Net-_C6-Pad1_ Net-_R5-Pad1_ NC_32 +3V3 NC_33 NC_34 NC_35 NC_36 Net-_D1-Pad1_ NC_37 /USBD+ /USBD- Net-_C6-Pad1_ +3V3 Net-_C6-Pad1_ +3V3 +3V3 Net-_D2-Pad1_ NC_38 +3V3 NC_39 NC_40 NC_41 FT232RL
C4 Net-_C4-Pad1_ +3V3 C_100nF
C7 +3V3 +3V3 C_0.1uF
C9 +3V3 +3V3 C_10uF
F1 +3V3 Net-_C4-Pad1_ F_500mA_16v
C6 Net-_C6-Pad1_ +3V3 C_0.1uF
R2 Net-_D2-Pad2_ +3V3 R_1K
R3 Net-_D1-Pad2_ +3V3 R_1K
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED_RX
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ LED_TX
R4 Net-_R4-Pad1_ /Rx R_1K
R5 Net-_R5-Pad1_ /Tx R_1K
U4 +3V3 +3V3 +3V3 NC_42 +3V3 MIC5205-3.3YM5
C10 +3V3 +3V3 C_10uF
C11 +3V3 +3V3 C_0.1uF
D3 +3V3 Net-_D3-Pad2_ SCK_LED
R7 Net-_D3-Pad2_ /SCK R_1K
D4 +3V3 Net-_D4-Pad2_ IO1_LED
R8 Net-_D4-Pad2_ /IO1 R_1K
D5 +3V3 Net-_D5-Pad2_ IO2_LED
R9 Net-_D5-Pad2_ /IO2 R_1K
D6 +3V3 Net-_D6-Pad2_ LED_RX
R10 Net-_D6-Pad2_ +3V3 R_1K
D7 +3V3 Net-_D7-Pad2_ LED_RX
R11 Net-_D7-Pad2_ +3V3 R_1K
U2 /MISO /Tx /SS +3V3 +3V3 /CAN_TX /CAN_RX /IO3 /MOSI Net-_C8-Pad1_ Net-_C5-Pad1_ /Rx /AIN6 /AIN7 /IO2 /AIN0 /AIN3 /AIN4 Net-_C2-Pad1_ +3V3 /AREF /AIN5 /IO4 /IO5 /AOUT0 /AIN1 /AIN2 /SCK /IO0 /IO6 /RESET /IO1 ATMEGA16M1
C3 +3V3 /AREF C_0.1uF
J2 /IO0 /IO1 /IO2 /IO3 /IO4 /IO5 /IO6 /Rx /Tx /CAN_TX /CAN_RX /MISO /MOSI /SCK /RESET Right Pins
J1 +3V3 +3V3 +3V3 +3V3 /AREF /SS /AOUT0 /AIN7 /AIN6 /AIN5 /AIN4 /AIN3 /AIN2 /AIN1 /AIN0 Left Pins
.end
