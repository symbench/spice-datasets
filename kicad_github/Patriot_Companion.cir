.title KiCad schematic
R5 Net-_C1-Pad1_ Net-_C2-Pad1_ 1M
Y1 Net-_C1-Pad1_ GND Net-_C2-Pad1_ GND 16M
C1 Net-_C1-Pad1_ GND 22p
C2 Net-_C2-Pad1_ GND 22p
U2 Net-_P3-Pad1_ +5V D- D+ GND Net-_C8-Pad1_ VUSB Net-_R6-Pad2_ SCK MOSI MISO NC_01 RESET +5V GND Net-_C2-Pad1_ Net-_C1-Pad1_ SCL SDA NEOPIXEL NC_02 Net-_R7-Pad2_ GND Net-_C12-Pad1_ BUTTON_B BUTTON_A SERVO NC_03 RIN1 FIN1 RIN2 FIN2 Net-_R8-Pad2_ +5V GND JOYSTICK_Y JOYSTICK_X Net-_P3-Pad5_ Net-_P3-Pad4_ Net-_P3-Pad3_ Net-_P3-Pad2_ Net-_C9-Pad1_ GND Net-_C12-Pad1_ ATMEGA32U4-A
R3 Net-_C4-Pad1_ RESET 10k
D1 Net-_C4-Pad1_ RESET CD1206-S01575
C4 Net-_C4-Pad1_ GND 0u1
C5 Net-_C4-Pad1_ GND 0u1
L2 +5V Net-_C12-Pad1_ MH2029-300Y
C12 Net-_C12-Pad1_ GND 1u0
SW1 GND RESET SWITCH
C8 Net-_C8-Pad1_ GND 1u0
C9 Net-_C9-Pad1_ GND 0u1
R8 GND Net-_R8-Pad2_ R
P4 MISO +5V SCK MOSI RESET GND CONN_02X03
P1 Net-_F1-Pad2_ Net-_P1-Pad2_ Net-_P1-Pad3_ NC_04 GND Net-_L1-Pad2_ USB_OTG
C7 VUSB GND C
C6 VUSB GND CP
RV1 Net-_P1-Pad2_ GND Varistor
RV2 Net-_P1-Pad3_ GND Varistor
L1 GND Net-_L1-Pad2_ Ferrite_Bead
F1 VUSB Net-_F1-Pad2_ Polyfuse
D2 Net-_C13-Pad1_ GND D
P2 GND Net-_F2-Pad2_ POWER_IN
C13 Net-_C13-Pad1_ GND CP
C15 +5V GND 10u
P5 Net-_P5-Pad1_ Net-_P5-Pad2_ MOTOR_1
R12 RIN1 GND 10k
R11 FIN1 GND 10k
C20 +5V GND 0u1
U7 +5V Net-_P6-Pad1_ FIN2 GND RIN2 Net-_P6-Pad2_ +5V GND BD6212HFP-TR
P6 Net-_P6-Pad1_ Net-_P6-Pad2_ MOTOR_2
R16 RIN2 GND 10k
R15 FIN2 GND 10k
C24 +5V GND 0u1
C16 +5V GND CP
C21 +5V GND 10u
C25 +5V GND 10u
D4 Net-_D4-Pad1_ +5V TXLED
D3 Net-_D3-Pad1_ +5V RXLED
R6 Net-_D3-Pad1_ Net-_R6-Pad2_ 1k
R7 Net-_D4-Pad1_ Net-_R7-Pad2_ 1k
LED1 Net-_LED1-Pad1_ GND NEOPIXEL +5V NeoPixel
LED2 Net-_LED2-Pad1_ GND Net-_LED1-Pad1_ +5V NeoPixel
LED3 NC_05 GND Net-_LED2-Pad1_ +5V NeoPixel
C14 +5V GND CP
SW2 BUTTON_A +5V SWITCH
SW3 BUTTON_B +5V SWITCH
R9 BUTTON_A GND 10k
R10 BUTTON_B GND 10k
R4 Net-_C9-Pad1_ +5V R
P7 SERVO +5V GND SERVO_HEADER
U9 +5V NC_06 NC_07 GND GND JOYSTICK_Y JOYSTICK_X +5V joystick
P3 Net-_P3-Pad1_ Net-_P3-Pad2_ Net-_P3-Pad3_ Net-_P3-Pad4_ Net-_P3-Pad5_ SCL SDA CONN_01X07
R14 D+ Net-_P1-Pad3_ R
R13 D- Net-_P1-Pad2_ R
U4 Net-_C13-Pad1_ GND +5V LF33CDT-TRY
U5 +5V Net-_P5-Pad1_ FIN1 GND RIN1 Net-_P5-Pad2_ +5V GND BD6212HFP-TR
D5 Net-_D5-Pad1_ +5V LED
R19 Net-_D5-Pad1_ GND R
F2 Net-_C13-Pad1_ Net-_F2-Pad2_ Polyfuse
C3 Net-_C13-Pad1_ GND 0u1
D6 +5V VUSB D
U1 SDA GND NC_08 SCL +5V NC_09 GND GND SHT30-DIS-B
R1 +5V SCL R
R2 +5V SDA R
C10 +5V GND C
.end
