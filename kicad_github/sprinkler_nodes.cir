.title KiCad schematic
J3 /MCLR +3V3 GND /ICSPDAT /ICSPCLK NC_01 HEADER_1X6
R5 Net-_C4-Pad1_ +3V3 RES_0603
C1 GND +3V3 CAP_0603
C4 Net-_C4-Pad1_ GND CAP_0603
U1 +3V3 /GPIO3 /CLKOUT /MCLR /UART_RX /UART_TX /SW_1 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 /GPIO2 /GPIO1 /AN4 /V_Temp /ICSPCLK /ICSPDAT GND PIC16F1829_SOIC
R1 Net-_OT1-Pad1_ /SW_1 RES_0603
R2 Net-_D1-PadA_ /SW_1 RES_0603
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ /VIN_GND /VIN_AC term_block_4-pin
D1 Net-_D1-PadA_ GND LED_0603
OT1 Net-_OT1-Pad1_ GND /TRIAC_G Net-_OT1-Pad4_ Opto-Triac-FODM30XX
U2 +5V /V_Temp GND Temp_SOT23-3
C2 GND +5V CAP_0603
D2 Net-_C4-Pad1_ /MCLR Schottky_SOD123
J2 /RF_IN /RF_IN_RTN /RF_OUT /RF_OUT_RTN term_block_4-pin
D12 /GPIO1 Net-_D12-PadC_ LED_0603
R6 Net-_D12-PadC_ GND RES_0603
D13 /GPIO2 Net-_D13-PadC_ LED_0603
R7 Net-_D13-PadC_ GND RES_0603
D14 /GPIO3 Net-_D14-PadC_ LED_0603
R8 Net-_D14-PadC_ GND RES_0603
U6 NC_08 +5V GND /AN4 NC_09 NC_10 NC_11 NC_12 MPX5100
C3 +5V GND CAP_0603
R32 Net-_C20-Pad1_ Net-_OT1-Pad4_ RES_0603
R31 Net-_Q3-Pad2_ Net-_C20-Pad1_ RES_0603
C20 Net-_C20-Pad1_ Net-_C19-Pad2_ CAP_0603
C19 Net-_C19-Pad1_ Net-_C19-Pad2_ CAP_0603
R30 Net-_C19-Pad1_ Net-_Q3-Pad2_ RES_0603
Q3 Net-_C19-Pad2_ Net-_Q3-Pad2_ /TRIAC_G Triac
R27 /VIN_AC Net-_Q3-Pad2_ RES_0603
R26 /LOAD Net-_Q3-Pad2_ RES_0603
R4 Net-_J1-Pad1_ /SW_1 RES_0603
R3 Net-_J1-Pad1_ /LOAD RES_0603
R24 Net-_J1-Pad2_ /VIN_GND RES_0603
R25 Net-_J1-Pad2_ GND RES_0603
R28 /LOAD Net-_C19-Pad2_ RES_0603
R29 /VIN_AC Net-_C19-Pad2_ RES_0603
U3 Net-_C6-Pad1_ GND Net-_R10-Pad1_ /power/EN /power/VIN Net-_C6-Pad2_ MP2456
D3 GND Net-_C6-Pad2_ Schottky_SOD123
C5 /power/VIN GND CAP_ELEC
BR1 GND /VIN_GND /VIN_AC /power/VIN MD5S_Diode_Bridge
C7 /power/VIN GND CAP_0805
C6 Net-_C6-Pad1_ Net-_C6-Pad2_ CAP_0603
C8 +5V GND CAP_0805
R9 +5V Net-_R10-Pad1_ RES_0603
R10 Net-_R10-Pad1_ GND RES_0603
L1 +5V Net-_C6-Pad2_ IND
U4 GND +3V3 +5V +3V3 TLV1117_3.3V
C10 +3V3 GND CAP_0805
C9 +5V GND CAP_0805
D4 +5V Net-_D4-PadC_ LED_0603
R11 GND Net-_D4-PadC_ RES_0603
R12 GND Net-_D6-PadC_ RES_0603
D6 +3V3 Net-_D6-PadC_ LED_0603
D5 +3V3 +5V Diode_SOD323
R23 /power/VIN /power/EN RES_0603
C11 /RF_IN Net-_C11-Pad2_ CAP_0603
R14 +5V Net-_C11-Pad2_ RES_0603
R13 Net-_C11-Pad2_ GND RES_0603
Q1 Net-_C11-Pad2_ Net-_D10-PadA_ +5V NPN
R16 Net-_D10-PadA_ GND RES_0603
C17 Net-_C16-Pad1_ Net-_C17-Pad2_ CAP_0603
C16 Net-_C16-Pad1_ GND CAP_0603
R17 Net-_C16-Pad1_ GND RES_0603
R20 Net-_C18-Pad1_ Net-_C17-Pad2_ RES_0603
C18 Net-_C18-Pad1_ GND CAP_0603
Q2 Net-_C18-Pad1_ GND Net-_Q2-Pad3_ NPN
R21 +3V3 Net-_Q2-Pad3_ RES_0603
R22 /UART_RX Net-_Q2-Pad3_ RES_0603
C13 Net-_C13-Pad1_ /RF_OUT CAP_0603
C15 +5V GND CAP_0603
R19 Net-_R18-Pad2_ /UART_TX RES_0603
R18 +5V Net-_R18-Pad2_ RES_0603
R15 Net-_C13-Pad1_ Net-_R15-Pad2_ RES_0603
U5 Net-_R18-Pad2_ /CLKOUT GND Net-_R15-Pad2_ +5V NC7SZ125
D9 GND Net-_C13-Pad1_ Zener_SOD323
C14 GND /RF_OUT_RTN CAP_0603
D7 GND Net-_C11-Pad2_ Zener_SOD323
D8 GND Net-_C11-Pad2_ Schottky_SOD323
D10 Net-_D10-PadA_ Net-_C16-Pad1_ Diode_SOD323
C12 /RF_IN_RTN GND CAP_0603
D11 GND Net-_C17-Pad2_ Schottky_SOD323
.end
