.title KiCad schematic
K37 GND /KEY37 K00
K38 GND /KEY38 K00
K39 GND /KEY39 K00
K40 GND /KEY40 K00
K33 GND /KEY33 K00
K34 GND /KEY34 K00
K35 GND /KEY35 K00
K36 GND /KEY36 K00
K13 GND /KEY13 K00
K14 GND /KEY14 K00
K15 GND /KEY15 K00
K16 GND /KEY16 K00
K9 GND /KEY9 K00
K10 GND /KEY10 K00
K11 GND /KEY11 K00
K12 GND /KEY12 K00
K21 GND /KEY21 K00
K22 GND /KEY22 K00
K23 GND /KEY23 K00
K24 GND /KEY24 K00
K17 GND /KEY17 K00
K18 GND /KEY17 K00
K19 GND /KEY19 K00
K20 GND /KEY20 K00
K29 GND /KEY29 K00
K30 GND /KEY30 K00
K31 GND /KEY31 K00
K32 GND /KEY32 K00
K25 GND /KEY25 K00
K26 GND /KEY26 K00
K27 GND /KEY27 K00
K28 GND /KEY28 K00
K61 GND /KEY61 K00
K62 GND /KEY62 K00
K63 GND /KEY63 K00
K64 GND /KEY64 K00
K57 GND /KEY57 K00
K58 GND /KEY58 K00
K59 GND /KEY59 K00
K60 GND /KEY60 K00
K69 GND /KEY69 K00
K70 GND /KEY70 K00
K71 GND /KEY71 K00
K65 GND /KEY65 K00
K66 GND /KEY66 K00
K67 GND /KEY67 K00
K68 GND /KEY68 K00
U2 /KEY63 /KEY62 GND VCC /KEY54 /KEY55 /KEY56 /KEY57 /KEY58 /KEY59 /KEY60 /KEY61 GND VCC /KEY70 /KEY71 /KEY72 /KEY77 /KEY78 /KEY79 /KEY80 /KEY81 GND VCC /KEY37 /KEY53 /KEY69 /KEY68 /KEY52 /KEY36 /D- /D+ GND VCC /KEY19 /KEY20 /KEY1 /KEY2 /KEY3 /KEY4 /KEY5 /KEY6 GND VCC /KEY7 /KEY8 /KEY9 /KEY10 /KEY11 /KEY12 /KEY13 /KEY14 GND VCC /KEY15 /KEY16 /KEY17 /KEY21 /KEY22 /KEY23 /KEY24 /KEY25 GND VCC /KEY26 /KEY27 /KEY28 /KEY29 /KEY30 /KEY31 /KEY32 /KEY33 GND VCC /KEY34 /KEY35 /KEY51 /KEY50 /KEY49 /KEY48 /KEY47 /KEY46 VCC GND /KEY38 /KEY39 /KEY40 /KEY41 /PDI /RST /KEY42 /KEY43 GND VCC /KEY44 /KEY45 /KEY67 /KEY66 /KEY65 /KEY64 ATXMEGA128A1U-AU
J2 GND +5V Net-_J2-PadA5_ /D+ /D- NC_01 +5V GND GND +5V Net-_J2-PadB5_ /D+ /D- NC_02 +5V GND NC_03 USB_Type_C_2.0_Receptacle
R2 Net-_J2-PadA5_ GND 5.1k
C2 GND VCC 0.1uF
C3 GND VCC 0.1uF
C4 GND VCC 0.1uF
C5 GND VCC 0.1uF
C1 GND VCC 10uF
J1 /PDI VCC NC_04 NC_05 /RST GND TC2030-IDC
C6 GND VCC 0.1uF
C7 GND VCC 0.1uF
K5 GND /KEY5 K00
K6 GND /KEY6 K00
K7 GND /KEY7 K00
K8 GND /KEY8 K00
K1 GND /KEY1 K00
K2 GND /KEY2 K00
K3 GND /KEY3 K00
K4 GND /KEY4 K00
K45 GND /KEY45 K00
K46 GND /KEY46 K00
K47 GND /KEY47 K00
K48 GND /KEY48 K00
K41 GND /KEY41 K00
K42 GND /KEY42 K00
K43 GND /KEY43 K00
K44 GND /KEY44 K00
K53 GND /KEY53 K00
K54 GND /KEY54 K00
K55 GND /KEY55 K00
K56 GND /KEY56 K00
K49 GND /KEY49 K00
K50 GND /KEY50 K00
K51 GND /KEY51 K00
K52 GND /KEY52 K00
C8 GND VCC 0.1uF
C9 GND VCC 0.1uF
C10 GND VCC 0.1uF
C11 GND VCC 0.1uF
K77 GND /KEY77 K00
K78 GND /KEY78 K00
K79 GND /KEY79 K00
K80 GND /KEY80 K00
K74 GND /KEY72 K00
K75 GND /KEY72 K00
K76 GND /KEY72 K00
K81 GND /KEY81 K00
U1 +5V GND +5V NC_06 VCC MIC5504-1.2YM5
R1 Net-_J2-PadB5_ GND 5.1k
K73 GND /KEY72 K00
K72 GND /KEY72 K00
.end
