.title KiCad schematic
SW1 Net-_D1-Pad2_ /COL0 SW_PUSH
D1 /ROW0 Net-_D1-Pad2_ D
SW2 Net-_D2-Pad2_ /COL1 SW_PUSH
D2 /ROW0 Net-_D2-Pad2_ D
SW3 Net-_D3-Pad2_ /COL2 SW_PUSH
D3 /ROW0 Net-_D3-Pad2_ D
SW4 Net-_D4-Pad2_ /COL3 SW_PUSH
D4 /ROW0 Net-_D4-Pad2_ D
SW5 Net-_D5-Pad2_ /COL4 SW_PUSH
D5 /ROW0 Net-_D5-Pad2_ D
SW6 Net-_D6-Pad2_ /COL5 SW_PUSH
D6 /ROW0 Net-_D6-Pad2_ D
SW7 Net-_D7-Pad2_ /COL6 SW_PUSH
D7 /ROW0 Net-_D7-Pad2_ D
SW8 Net-_D8-Pad2_ /COL7 SW_PUSH
D8 /ROW0 Net-_D8-Pad2_ D
SW9 Net-_D9-Pad2_ /COL8 SW_PUSH
D9 /ROW0 Net-_D9-Pad2_ D
SW10 Net-_D10-Pad2_ /COL9 SW_PUSH
D10 /ROW0 Net-_D10-Pad2_ D
SW11 Net-_D11-Pad2_ /COL10 SW_PUSH
D11 /ROW0 Net-_D11-Pad2_ D
SW12 Net-_D12-Pad2_ /COL11 SW_PUSH
D12 /ROW0 Net-_D12-Pad2_ D
SW13 Net-_D13-Pad2_ /COL12 SW_PUSH
D13 /ROW0 Net-_D13-Pad2_ D
SW14 Net-_D14-Pad2_ /COL13 SW_PUSH
D14 /ROW0 Net-_D14-Pad2_ D
SW15 Net-_D15-Pad2_ /COL14 SW_PUSH
D15 /ROW0 Net-_D15-Pad2_ D
SW16 Net-_D16-Pad2_ /COL15 SW_PUSH
D16 /ROW0 Net-_D16-Pad2_ D
SW17 Net-_D17-Pad2_ /COL16 SW_PUSH
D17 /ROW0 Net-_D17-Pad2_ D
SW18 Net-_D18-Pad2_ /COL17 SW_PUSH
D18 /ROW0 Net-_D18-Pad2_ D
SW21 Net-_D19-Pad2_ /COL0 SW_PUSH
D19 /ROW1 Net-_D19-Pad2_ D
SW22 Net-_D20-Pad2_ /COL1 SW_PUSH
D20 /ROW1 Net-_D20-Pad2_ D
SW23 Net-_D21-Pad2_ /COL2 SW_PUSH
D21 /ROW1 Net-_D21-Pad2_ D
SW24 Net-_D22-Pad2_ /COL3 SW_PUSH
D22 /ROW1 Net-_D22-Pad2_ D
SW25 Net-_D23-Pad2_ /COL4 SW_PUSH
D23 /ROW1 Net-_D23-Pad2_ D
SW26 Net-_D24-Pad2_ /COL5 SW_PUSH
D24 /ROW1 Net-_D24-Pad2_ D
SW27 Net-_D25-Pad2_ /COL6 SW_PUSH
D25 /ROW1 Net-_D25-Pad2_ D
SW28 Net-_D26-Pad2_ /COL7 SW_PUSH
D26 /ROW1 Net-_D26-Pad2_ D
SW29 Net-_D27-Pad2_ /COL8 SW_PUSH
D27 /ROW1 Net-_D27-Pad2_ D
SW30 Net-_D28-Pad2_ /COL9 SW_PUSH
D28 /ROW1 Net-_D28-Pad2_ D
SW31 Net-_D29-Pad2_ /COL10 SW_PUSH
D29 /ROW1 Net-_D29-Pad2_ D
SW32 Net-_D30-Pad2_ /COL11 SW_PUSH
D30 /ROW1 Net-_D30-Pad2_ D
SW33 Net-_D31-Pad2_ /COL12 SW_PUSH
D31 /ROW1 Net-_D31-Pad2_ D
SW34 Net-_D32-Pad2_ /COL14 SW_PUSH
D32 /ROW1 Net-_D32-Pad2_ D
SW35 Net-_D33-Pad2_ /COL15 SW_PUSH
D33 /ROW1 Net-_D33-Pad2_ D
SW36 Net-_D34-Pad2_ /COL16 SW_PUSH
D34 /ROW1 Net-_D34-Pad2_ D
SW38 Net-_D36-Pad2_ /COL0 SW_PUSH
D36 /ROW2 Net-_D36-Pad2_ D
SW39 Net-_D37-Pad2_ /COL1 SW_PUSH
D37 /ROW2 Net-_D37-Pad2_ D
SW40 Net-_D38-Pad2_ /COL2 SW_PUSH
D38 /ROW2 Net-_D38-Pad2_ D
SW41 Net-_D39-Pad2_ /COL3 SW_PUSH
D39 /ROW2 Net-_D39-Pad2_ D
SW42 Net-_D40-Pad2_ /COL4 SW_PUSH
D40 /ROW2 Net-_D40-Pad2_ D
SW43 Net-_D41-Pad2_ /COL5 SW_PUSH
D41 /ROW2 Net-_D41-Pad2_ D
SW44 Net-_D42-Pad2_ /COL6 SW_PUSH
D42 /ROW2 Net-_D42-Pad2_ D
SW45 Net-_D43-Pad2_ /COL7 SW_PUSH
D43 /ROW2 Net-_D43-Pad2_ D
SW46 Net-_D44-Pad2_ /COL8 SW_PUSH
D44 /ROW2 Net-_D44-Pad2_ D
SW47 Net-_D45-Pad2_ /COL9 SW_PUSH
D45 /ROW2 Net-_D45-Pad2_ D
SW48 Net-_D46-Pad2_ /COL10 SW_PUSH
D46 /ROW2 Net-_D46-Pad2_ D
SW49 Net-_D47-Pad2_ /COL11 SW_PUSH
D47 /ROW2 Net-_D47-Pad2_ D
SW50 Net-_D48-Pad2_ /COL12 SW_PUSH
D48 /ROW2 Net-_D48-Pad2_ D
SW51 Net-_D49-Pad2_ /COL14 SW_PUSH
D49 /ROW2 Net-_D49-Pad2_ D
SW52 Net-_D50-Pad2_ /COL16 SW_PUSH
D50 /ROW2 Net-_D50-Pad2_ D
SW54 Net-_D52-Pad2_ /COL0 SW_PUSH
D52 /ROW3 Net-_D52-Pad2_ D
SW55 Net-_D53-Pad2_ /COL1 SW_PUSH
D53 /ROW3 Net-_D53-Pad2_ D
SW56 Net-_D54-Pad2_ /COL2 SW_PUSH
D54 /ROW3 Net-_D54-Pad2_ D
SW57 Net-_D55-Pad2_ /COL3 SW_PUSH
D55 /ROW3 Net-_D55-Pad2_ D
SW58 Net-_D56-Pad2_ /COL4 SW_PUSH
D56 /ROW3 Net-_D56-Pad2_ D
SW59 Net-_D57-Pad2_ /COL5 SW_PUSH
D57 /ROW3 Net-_D57-Pad2_ D
SW60 Net-_D58-Pad2_ /COL6 SW_PUSH
D58 /ROW3 Net-_D58-Pad2_ D
SW61 Net-_D59-Pad2_ /COL7 SW_PUSH
D59 /ROW3 Net-_D59-Pad2_ D
SW62 Net-_D60-Pad2_ /COL8 SW_PUSH
D60 /ROW3 Net-_D60-Pad2_ D
SW63 Net-_D61-Pad2_ /COL9 SW_PUSH
D61 /ROW3 Net-_D61-Pad2_ D
SW64 Net-_D62-Pad2_ /COL10 SW_PUSH
D62 /ROW3 Net-_D62-Pad2_ D
SW65 Net-_D63-Pad2_ /COL11 SW_PUSH
D63 /ROW3 Net-_D63-Pad2_ D
SW66 Net-_D64-Pad2_ /COL12 SW_PUSH
D64 /ROW3 Net-_D64-Pad2_ D
SW67 Net-_D65-Pad2_ /COL15 SW_PUSH
D65 /ROW3 Net-_D65-Pad2_ D
SW68 Net-_D66-Pad2_ /COL16 SW_PUSH
D66 /ROW3 Net-_D66-Pad2_ D
SW70 Net-_D68-Pad2_ /COL0 SW_PUSH
D68 /ROW4 Net-_D68-Pad2_ D
SW71 Net-_D69-Pad2_ /COL1 SW_PUSH
D69 /ROW4 Net-_D69-Pad2_ D
SW72 Net-_D70-Pad2_ /COL2 SW_PUSH
D70 /ROW4 Net-_D70-Pad2_ D
SW73 Net-_D71-Pad2_ /COL3 SW_PUSH
D71 /ROW4 Net-_D71-Pad2_ D
SW74 Net-_D72-Pad2_ /COL4 SW_PUSH
D72 /ROW4 Net-_D72-Pad2_ D
SW75 Net-_D73-Pad2_ /COL5 SW_PUSH
D73 /ROW4 Net-_D73-Pad2_ D
SW76 Net-_D74-Pad2_ /COL7 SW_PUSH
D74 /ROW4 Net-_D74-Pad2_ D
SW77 Net-_D75-Pad2_ /COL8 SW_PUSH
D75 /ROW4 Net-_D75-Pad2_ D
SW78 Net-_D76-Pad2_ /COL10 SW_PUSH
D76 /ROW4 Net-_D76-Pad2_ D
SW79 Net-_D77-Pad2_ /COL12 SW_PUSH
D77 /ROW4 Net-_D77-Pad2_ D
SW80 Net-_D78-Pad2_ /COL15 SW_PUSH
D78 /ROW4 Net-_D78-Pad2_ D
SW81 Net-_D79-Pad2_ /COL16 SW_PUSH
D79 /ROW4 Net-_D79-Pad2_ D
U2 /COL0 /COL1 /COL2 /COL3 /COL4 /COL5 /COL6 GND VCC /COL7 /COL8 /COL9 /COL10 /COL11 /COL12 /COL14 /COL15 GND VCC /COL16 /COL17 /COL18 /COL19 /COL20 /COL21 Net-_J1-PadA7_ Net-_J1-PadA6_ NC_01 NC_02 GND VCC NC_03 NC_04 /PDI /RST /ROW4 /ROW3 GND VCC NC_05 /ROW2 /ROW0 /ROW1 /COL13 GND ATXMEGA-A4U-EPAD
J1 GND +5V Net-_J1-PadA5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_06 +5V GND GND +5V Net-_J1-PadB5_ Net-_J1-PadA6_ Net-_J1-PadA7_ NC_07 +5V GND GND USB_Type_C_2.0_Receptacle
U1 +5V GND +5V NC_08 VCC MIC550X
P1 /PDI VCC NC_09 NC_10 /RST GND TC2030-IDC
R1 Net-_J1-PadB5_ GND 5.1
R2 Net-_J1-PadA5_ GND 5.1
C1 VCC GND 10uf
C2 VCC GND 0.4uf
SW19 Net-_D17-Pad2_ /COL16 SW_PUSH
SW20 Net-_D16-Pad2_ /COL15 SW_PUSH
SW83 Net-_D74-Pad2_ /COL7 SW_PUSH
SW84 Net-_D75-Pad2_ /COL8 SW_PUSH
D80 /ROW4 Net-_D80-Pad2_ D
SW82 Net-_D80-Pad2_ /COL17 SW_PUSH
D67 /ROW3 Net-_D67-Pad2_ D
SW69 Net-_D67-Pad2_ /COL17 SW_PUSH
D51 /ROW2 Net-_D51-Pad2_ D
SW53 Net-_D51-Pad2_ /COL17 SW_PUSH
D35 /ROW1 Net-_D35-Pad2_ D
SW37 Net-_D35-Pad2_ /COL17 SW_PUSH
SW85 Net-_D81-Pad2_ /COL18 SW_PUSH
D81 /ROW0 Net-_D81-Pad2_ D
SW86 Net-_D82-Pad2_ /COL19 SW_PUSH
D82 /ROW0 Net-_D82-Pad2_ D
SW87 Net-_D83-Pad2_ /COL20 SW_PUSH
D83 /ROW0 Net-_D83-Pad2_ D
SW88 Net-_D84-Pad2_ /COL21 SW_PUSH
D84 /ROW0 Net-_D84-Pad2_ D
SW89 Net-_D85-Pad2_ /COL18 SW_PUSH
D85 /ROW1 Net-_D85-Pad2_ D
SW90 Net-_D86-Pad2_ /COL19 SW_PUSH
D86 /ROW1 Net-_D86-Pad2_ D
SW91 Net-_D87-Pad2_ /COL20 SW_PUSH
D87 /ROW1 Net-_D87-Pad2_ D
SW92 Net-_D88-Pad2_ /COL21 SW_PUSH
D88 /ROW1 Net-_D88-Pad2_ D
SW94 Net-_D89-Pad2_ /COL18 SW_PUSH
D89 /ROW2 Net-_D89-Pad2_ D
SW95 Net-_D90-Pad2_ /COL19 SW_PUSH
D90 /ROW2 Net-_D90-Pad2_ D
SW96 Net-_D91-Pad2_ /COL20 SW_PUSH
D91 /ROW2 Net-_D91-Pad2_ D
SW97 Net-_D92-Pad2_ /COL21 SW_PUSH
D92 /ROW2 Net-_D92-Pad2_ D
SW98 Net-_D93-Pad2_ /COL18 SW_PUSH
D93 /ROW3 Net-_D93-Pad2_ D
SW99 Net-_D94-Pad2_ /COL19 SW_PUSH
D94 /ROW3 Net-_D94-Pad2_ D
SW100 Net-_D95-Pad2_ /COL20 SW_PUSH
D95 /ROW3 Net-_D95-Pad2_ D
SW101 Net-_D96-Pad2_ /COL21 SW_PUSH
D96 /ROW3 Net-_D96-Pad2_ D
SW103 Net-_D97-Pad2_ /COL18 SW_PUSH
D97 /ROW4 Net-_D97-Pad2_ D
SW104 Net-_D98-Pad2_ /COL19 SW_PUSH
D98 /ROW4 Net-_D98-Pad2_ D
SW105 Net-_D99-Pad2_ /COL20 SW_PUSH
D99 /ROW4 Net-_D99-Pad2_ D
SW106 Net-_D100-Pad2_ /COL21 SW_PUSH
D100 /ROW4 Net-_D100-Pad2_ D
SW93 Net-_D92-Pad2_ /COL21 SW_PUSH
SW102 Net-_D100-Pad2_ /COL21 SW_PUSH
SW107 Net-_D97-Pad2_ /COL18 SW_PUSH
.end
