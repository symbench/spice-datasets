.title KiCad schematic
J2 /B12 /B13 /B14 /B15 /A8 NC_01 /A10 /A11 /A12 /A13 /B3 /B4 /B5 /B6 /B7 /B8 /B9 NC_02 GND +3V3 Conn_01x20_Female
J3 NC_03 NC_04 /C14 /C15 /A0 /A1 /A2 /A3 /A4 NC_05 NC_06 NC_07 NC_08 NC_09 /B10 /B11 NC_10 +3V3 GND GND Conn_01x20_Female
J1 /B11 /B10 NC_11 GND i2c display
SW1 /C15 /C14 GND +3V3 /A8 Rotary_Encoder_Switch
R1 GND /A8 500
R2 /C15 +3V3 500
R3 /C14 +3V3 500
S1 /A0 Net-_D1-Pad2_ esc
D1 /B3 Net-_D1-Pad2_ D_Schottky
S2 /A1 Net-_D2-Pad2_ tab1.5
D2 /B3 Net-_D2-Pad2_ D_Schottky
S3 /A2 Net-_D3-Pad2_ caps1.75
D3 /B3 Net-_D3-Pad2_ D_Schottky
S4 /A3 Net-_D4-Pad2_ shiftl_225
D4 /B3 Net-_D4-Pad2_ D_Schottky
S5 NC_12 Net-_D5-Pad2_ ctrl_125
D5 /B3 Net-_D5-Pad2_ D_Schottky
S6 /A0 Net-_D6-Pad2_ 1
D6 /B4 Net-_D6-Pad2_ D_Schottky
S7 /A1 Net-_D7-Pad2_ q
D7 NC_13 Net-_D7-Pad2_ D_Schottky
S8 /A2 Net-_D8-Pad2_ a
D8 NC_14 Net-_D8-Pad2_ D_Schottky
S9 /A3 Net-_D9-Pad2_ z
D9 /B4 Net-_D9-Pad2_ D_Schottky
S10 /A4 Net-_D10-Pad2_ win
D10 /B4 Net-_D10-Pad2_ D_Schottky
S11 /A0 Net-_D11-Pad2_ 2
D11 /B5 Net-_D11-Pad2_ D_Schottky
S12 /A1 Net-_D12-Pad2_ w
D12 /B5 Net-_D12-Pad2_ D_Schottky
S13 /A2 Net-_D13-Pad2_ s
D13 /B5 Net-_D13-Pad2_ D_Schottky
S14 /A3 Net-_D14-Pad2_ x
D14 /B5 Net-_D14-Pad2_ D_Schottky
S15 /A4 Net-_D15-Pad2_ lalt
D15 /B5 Net-_D15-Pad2_ D_Schottky
S16 /A0 Net-_D16-Pad2_ 3
D16 /B6 Net-_D16-Pad2_ D_Schottky
S17 /A1 Net-_D17-Pad2_ e
D17 /B6 Net-_D17-Pad2_ D_Schottky
S18 /A2 Net-_D18-Pad2_ d
D18 /B6 Net-_D18-Pad2_ D_Schottky
S19 /A3 Net-_D19-Pad2_ c
D19 /B6 Net-_D19-Pad2_ D_Schottky
S20 /A0 Net-_D20-Pad2_ 4
D20 /B7 Net-_D20-Pad2_ D_Schottky
S21 /A1 Net-_D21-Pad2_ r
D21 /B7 Net-_D21-Pad2_ D_Schottky
S22 /A2 Net-_D22-Pad2_ f
D22 /B7 Net-_D22-Pad2_ D_Schottky
S23 /A3 Net-_D23-Pad2_ v
D23 /B7 Net-_D23-Pad2_ D_Schottky
S24 /A0 Net-_D24-Pad2_ 5
D24 /B8 Net-_D24-Pad2_ D_Schottky
S25 NC_15 Net-_D25-Pad2_ t
D25 NC_16 Net-_D25-Pad2_ D_Schottky
S26 NC_17 Net-_D26-Pad2_ g
D26 /B8 Net-_D26-Pad2_ D_Schottky
S27 /A3 Net-_D27-Pad2_ b
D27 /B8 Net-_D27-Pad2_ D_Schottky
S28 /A4 Net-_D28-Pad2_ space
D28 /B8 Net-_D28-Pad2_ D_Schottky
S29 /A0 Net-_D29-Pad2_ 6
D29 /B9 Net-_D29-Pad2_ D_Schottky
S30 /A1 Net-_D30-Pad2_ y
D30 /B9 Net-_D30-Pad2_ D_Schottky
S31 /A2 Net-_D31-Pad2_ h
D31 /B9 Net-_D31-Pad2_ D_Schottky
S32 NC_18 Net-_D32-Pad2_ n
D32 /B9 Net-_D32-Pad2_ D_Schottky
S33 /A0 Net-_D33-Pad2_ 7
D33 /A10 Net-_D33-Pad2_ D_Schottky
S34 /A1 Net-_D34-Pad2_ u
D34 /A10 Net-_D34-Pad2_ D_Schottky
S35 /A2 Net-_D35-Pad2_ j
D35 /A10 Net-_D35-Pad2_ D_Schottky
S36 /A3 Net-_D36-Pad2_ m
D36 /A10 Net-_D36-Pad2_ D_Schottky
S37 /A0 Net-_D37-Pad2_ 8
D37 /A11 Net-_D37-Pad2_ D_Schottky
S38 /A1 Net-_D38-Pad2_ i
D38 /A11 Net-_D38-Pad2_ D_Schottky
S39 /A2 Net-_D39-Pad2_ k
D39 /A11 Net-_D39-Pad2_ D_Schottky
S40 /A3 Net-_D40-Pad2_ ,
D40 /A11 Net-_D40-Pad2_ D_Schottky
S41 /A4 Net-_D41-Pad2_ ralt
D41 /A11 Net-_D41-Pad2_ D_Schottky
S42 /A0 Net-_D42-Pad2_ 9
D42 /A12 Net-_D42-Pad2_ D_Schottky
S43 /A1 Net-_D43-Pad2_ o
D43 /A12 Net-_D43-Pad2_ D_Schottky
S44 /A2 Net-_D44-Pad2_ l
D44 /A12 Net-_D44-Pad2_ D_Schottky
S45 /A4 Net-_D45-Pad2_ fn
D45 /A12 Net-_D45-Pad2_ D_Schottky
S46 /A0 Net-_D46-Pad2_ 0
D46 /A13 Net-_D46-Pad2_ D_Schottky
S47 /A1 Net-_D47-Pad2_ p
D47 /A13 Net-_D47-Pad2_ D_Schottky
S48 /A2 Net-_D48-Pad2_ ;
D48 /A13 Net-_D48-Pad2_ D_Schottky
S49 /A3 Net-_D49-Pad2_ /
D49 /A13 Net-_D49-Pad2_ D_Schottky
S50 /A4 Net-_D50-Pad2_ mod
D50 /A13 Net-_D50-Pad2_ D_Schottky
S51 /A0 Net-_D51-Pad2_ esc
D51 /B12 Net-_D51-Pad2_ D_Schottky
S52 /A1 Net-_D52-Pad2_ [
D52 /B12 Net-_D52-Pad2_ D_Schottky
S53 /A0 Net-_D53-Pad2_ bkspc_2.0
D53 /B13 Net-_D53-Pad2_ D_Schottky
S54 /A2 Net-_D54-Pad2_ ]
D54 /B12 Net-_D54-Pad2_ D_Schottky
S55 /A2 Net-_D55-Pad2_ enter
D55 /B13 Net-_D55-Pad2_ D_Schottky
S56 /A3 Net-_D56-Pad2_ arrowmod1.0
D56 /B13 Net-_D56-Pad2_ D_Schottky
S57 /A4 Net-_D57-Pad2_ mod2
D57 /B12 Net-_D57-Pad2_ D_Schottky
S58 /A0 Net-_D58-Pad2_ prog0
D58 /B14 Net-_D58-Pad2_ D_Schottky
S59 NC_19 Net-_D59-Pad2_ prog1
D59 /B14 Net-_D59-Pad2_ D_Schottky
S60 NC_20 Net-_D60-Pad2_ prog3
D60 /B14 Net-_D60-Pad2_ D_Schottky
S61 NC_21 Net-_D61-Pad2_ prog5
D61 /B14 Net-_D61-Pad2_ D_Schottky
S62 NC_22 Net-_D62-Pad2_ prog7
D62 /B14 Net-_D62-Pad2_ D_Schottky
S64 /A1 Net-_D64-Pad2_ prog2
D64 /B15 Net-_D64-Pad2_ D_Schottky
S65 /A2 Net-_D65-Pad2_ prog4
D65 /B15 Net-_D65-Pad2_ D_Schottky
S66 /A3 Net-_D66-Pad2_ pro6
D66 /B15 Net-_D66-Pad2_ D_Schottky
S67 /A4 Net-_D67-Pad2_ prog8
D67 /B15 Net-_D67-Pad2_ D_Schottky
S69 /A3 Net-_D69-Pad2_ 1.75
D69 /B12 Net-_D69-Pad2_ D_Schottky
S68 /A3 Net-_D68-Pad2_ .
D68 /A12 Net-_D68-Pad2_ D_Schottky
D70 /B13 Net-_D70-Pad2_ D_Schottky
S70 /A1 Net-_D70-Pad2_ \
S63 /A2 Net-_D63-Pad2_ '
D63 /B12 Net-_D63-Pad2_ D_Schottky
.end
