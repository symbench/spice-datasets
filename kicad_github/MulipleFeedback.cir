.title KiCad schematic
C5 NC_01 Net-_C5-Pad2_ C
C7 NC_02 Net-_C5-Pad2_ C
C6 Net-_C6-Pad1_ NC_03 C
C8 Net-_C6-Pad1_ NC_04 C
J4 Net-_C5-Pad2_ NC_05 Net-_J4-Pad3_ Net-_J4-Pad3_ NC_06 Net-_C6-Pad1_ InConnector
J5 NC_07 NC_08 Net-_J5-Pad3_ Net-_J5-Pad3_ NC_09 NC_10 OutConnector
U2 NC_11 Net-_R10-Pad1_ NC_12 NC_13 NC_14 Net-_J5-Pad3_ NC_15 NC_16 OPA333xxD
R10 Net-_R10-Pad1_ Net-_J5-Pad3_ R
R7 NC_17 Net-_R6-Pad2_ R
R8 Net-_R6-Pad2_ Net-_J5-Pad3_ R
R9 Net-_R6-Pad2_ Net-_R10-Pad1_ R
R6 Net-_J4-Pad3_ Net-_R6-Pad2_ R
C13 NC_18 Net-_C13-Pad2_ C
C15 NC_19 Net-_C13-Pad2_ C
C14 Net-_C14-Pad1_ NC_20 C
C16 Net-_C14-Pad1_ NC_21 C
J8 Net-_C13-Pad2_ NC_22 Net-_J8-Pad3_ Net-_J8-Pad3_ NC_23 Net-_C14-Pad1_ InConnector
J9 NC_24 NC_25 Net-_J9-Pad3_ Net-_J9-Pad3_ NC_26 NC_27 OutConnector
R15 Net-_R14-Pad2_ Net-_R13-Pad2_ R
R12 NC_28 Net-_R11-Pad2_ R
R13 Net-_R11-Pad2_ Net-_R13-Pad2_ R
R14 Net-_R11-Pad2_ Net-_R14-Pad2_ R
R11 Net-_J8-Pad3_ Net-_R11-Pad2_ R
U3 Net-_R13-Pad2_ Net-_R14-Pad2_ NC_29 NC_30 NC_31 Net-_R19-Pad2_ Net-_J9-Pad3_ NC_32 ADA4807-2ARM
R20 Net-_R19-Pad2_ Net-_J9-Pad3_ R
R17 NC_33 Net-_R16-Pad2_ R
R18 Net-_R16-Pad2_ Net-_J9-Pad3_ R
R19 Net-_R16-Pad2_ Net-_R19-Pad2_ R
R16 Net-_R13-Pad2_ Net-_R16-Pad2_ R
C21 NC_34 Net-_C21-Pad2_ C
C23 NC_35 Net-_C21-Pad2_ C
C22 Net-_C22-Pad1_ NC_36 C
C24 Net-_C22-Pad1_ NC_37 C
J12 Net-_C21-Pad2_ NC_38 Net-_J12-Pad3_ Net-_J12-Pad4_ NC_39 Net-_C22-Pad1_ InConnector
J13 Net-_C25-Pad2_ NC_40 Net-_J13-Pad3_ Net-_J13-Pad4_ NC_41 Net-_C26-Pad1_ OutConnector
U5 NC_42 Net-_R46-Pad2_ NC_43 NC_44 NC_45 Net-_J13-Pad3_ NC_46 NC_47 OPA333xxD
R49 Net-_R46-Pad2_ Net-_J13-Pad3_ R
R43 NC_48 Net-_R41-Pad2_ R
R45 Net-_R41-Pad2_ Net-_J13-Pad3_ R
R46 Net-_R41-Pad2_ Net-_R46-Pad2_ R
R41 Net-_J12-Pad3_ Net-_R41-Pad2_ R
U6 NC_49 Net-_R48-Pad2_ NC_50 NC_51 NC_52 Net-_J13-Pad4_ NC_53 NC_54 OPA333xxD
R50 Net-_R48-Pad2_ Net-_J13-Pad4_ R
R44 NC_55 Net-_R42-Pad2_ R
R47 Net-_R42-Pad2_ Net-_J13-Pad4_ R
R48 Net-_R42-Pad2_ Net-_R48-Pad2_ R
R42 Net-_J12-Pad4_ Net-_R42-Pad2_ R
C25 NC_56 Net-_C25-Pad2_ C
C27 NC_57 Net-_C25-Pad2_ C
C26 Net-_C26-Pad1_ NC_58 C
C28 Net-_C26-Pad1_ NC_59 C
C29 NC_60 Net-_C29-Pad2_ C
C31 NC_61 Net-_C29-Pad2_ C
C30 Net-_C30-Pad1_ NC_62 C
C32 Net-_C30-Pad1_ NC_63 C
J14 Net-_C29-Pad2_ NC_64 Net-_J14-Pad3_ Net-_J14-Pad4_ NC_65 Net-_C30-Pad1_ InConnector
J15 Net-_C33-Pad2_ NC_66 Net-_J15-Pad3_ Net-_J15-Pad4_ NC_67 Net-_C34-Pad1_ OutConnector
R59 Net-_R56-Pad2_ Net-_R55-Pad2_ R
R53 NC_68 Net-_R51-Pad2_ R
R55 Net-_R51-Pad2_ Net-_R55-Pad2_ R
R56 Net-_R51-Pad2_ Net-_R56-Pad2_ R
R51 Net-_J14-Pad3_ Net-_R51-Pad2_ R
U7 Net-_R55-Pad2_ Net-_R56-Pad2_ NC_69 NC_70 NC_71 Net-_R66-Pad2_ Net-_J15-Pad3_ NC_72 ADA4807-2ARM
R69 Net-_R66-Pad2_ Net-_J15-Pad3_ R
R63 NC_73 Net-_R61-Pad2_ R
R65 Net-_R61-Pad2_ Net-_J15-Pad3_ R
R66 Net-_R61-Pad2_ Net-_R66-Pad2_ R
R61 Net-_R55-Pad2_ Net-_R61-Pad2_ R
R60 Net-_R58-Pad2_ Net-_R57-Pad2_ R
R54 NC_74 Net-_R52-Pad2_ R
R57 Net-_R52-Pad2_ Net-_R57-Pad2_ R
R58 Net-_R52-Pad2_ Net-_R58-Pad2_ R
R52 Net-_J14-Pad4_ Net-_R52-Pad2_ R
U8 Net-_R57-Pad2_ Net-_R58-Pad2_ NC_75 NC_76 NC_77 Net-_R68-Pad2_ Net-_J15-Pad4_ NC_78 ADA4807-2ARM
R70 Net-_R68-Pad2_ Net-_J15-Pad4_ R
R64 NC_79 Net-_R62-Pad2_ R
R67 Net-_R62-Pad2_ Net-_J15-Pad4_ R
R68 Net-_R62-Pad2_ Net-_R68-Pad2_ R
R62 Net-_R57-Pad2_ Net-_R62-Pad2_ R
C33 NC_80 Net-_C33-Pad2_ C
C35 NC_81 Net-_C33-Pad2_ C
C34 Net-_C34-Pad1_ NC_82 C
C36 Net-_C34-Pad1_ NC_83 C
.end
