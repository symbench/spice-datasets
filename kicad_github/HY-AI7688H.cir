.title KiCad schematic
U2 GND /AI7688H/JTMS_GPIO_41 /AI7688H/JTDO_EPHY_LED0_N /AI7688H/JRST_GPIO_39 /AI7688H/UART_7688_TXD1 /AI7688H/UART_7688_RXD1 /AI7688H/I2S_SDI /AI7688H/I2S_SDO /AI7688H/I2S_WS /AI7688H/I2S_SCLK /AI7688H/I2C_SCLK /AI7688H/I2C_SD GND /AI7688H/MDI_P0_R_P /AI7688H/MDI_P0_R_N /AI7688H/MDI_P0_T_P /AI7688H/MDI_P0_T_N /AI7688H/GPIO_0 /AI7688H/UART_7688_TXD0 /AI7688H/UART_7688_RXD0 /AI7688H/USB_D_P /AI7688H/USB_D_N GND /AI7688H/MDI_TN_P3 /AI7688H/MDI_RP_P3 /AI7688H/MDI_RN_P3 /AI7688H/MDI_RP_P4 /AI7688H/MDI_RN_P4 /AI7688H/MDI_TP_P4 /AI7688H/MDI_TN_P4 GND /AI7688H/MDI_TN_P2 /AI7688H/MDI_TP_P2 /AI7688H/MDI_RN_P2 /AI7688H/MDI_RP_P2 /AI7688H/MDI_RN_P1 /AI7688H/MDI_RP_P1 /AI7688H/MDI_TN_P1 /AI7688H/MDI_TP_P1 GND GND GND GND GND /AI7688H/WLED_N /AI7688H/REF_CLKO /AI7688H/PERST_N /AI7688H/WDT_RST_N /AI7688H/PORST_N /AI7688H/PCIE_TX0_P /AI7688H/PCIE_TX0_N /AI7688H/PCIE_RX0_P /AI7688H/PCIE_RX0_N +3V3 /AI7688H/PCIE_CK0_N /AI7688H/PCIE_CK0_P /AI7688H/JTCLK_GPIO_40 /AI7688H/JTDI_GPIO_42 GND /AI7688H/RF GND GND GND GND GND AI7688H
R9 +3V3 Net-_P3-Pad9_ 330R
R10 +3V3 Net-_P3-Pad12_ 330R
C12 GND Net-_C12-Pad2_ 100nF
C13 GND Net-_C13-Pad2_ 100nF
P3 /AI7688H/MDI_P0_R_P /AI7688H/MDI_P0_R_N Net-_C12-Pad2_ GND GND Net-_C13-Pad2_ /AI7688H/MDI_P0_T_P /AI7688H/MDI_P0_T_N Net-_P3-Pad9_ /AI7688H/EPHY_LED0_N /AI7688H/EPHY_LED0_N Net-_P3-Pad12_ GND GND HR911102A
SW3 /AI7688H/PORST_N GND MPU_RESET
C1 GND /AI7688H/MDI_P0_R_P DNP
C4 GND /AI7688H/MDI_P0_R_N DNP
C5 GND /AI7688H/MDI_P0_T_P DNP
C6 GND /AI7688H/MDI_P0_T_N DNP
P2 +5V /AI7688H/USB_D_N /AI7688H/USB_D_P GND GND USB_A
C3 GND +5V 100nF
C2 GND +5V 10uF
D3 /AI7688H/USB_D_P GND TVS
D4 /AI7688H/USB_D_N GND TVS
C17 GND +3V3 100nF
C16 GND +3V3 100uF
P1 Net-_FB1-Pad1_ Net-_D2-Pad1_ Net-_D1-Pad1_ NC_01 GND GND USB_OTG
D1 Net-_D1-Pad1_ GND TVS
FB1 Net-_FB1-Pad1_ +5V_USBOTG FBM0805PT800S
C7 GND +5V_USBOTG 10uF
D2 Net-_D2-Pad1_ GND TVS
CON1 /AI7688H/MDI_TN_P4 /AI7688H/MDI_TP_P4 /AI7688H/MDI_RN_P4 +3V3 Net-_C8-Pad2_ GND /AI7688H/MDI_RN_P3 /AI7688H/MDI_RP_P3 /AI7688H/MDI_TN_P3 GND GND GND GND NC_02 NC_03 TF-Micro-SDCard
C11 GND +3V3 100nF
C9 GND +3V3 NC
R8 /AI7688H/MDI_TN_P4 +3V3 10K
R7 /AI7688H/MDI_TP_P4 +3V3 10K
R6 /AI7688H/MDI_RN_P4 +3V3 10K
R4 /AI7688H/MDI_RN_P3 +3V3 10K
R3 /AI7688H/MDI_RP_P3 +3V3 10K
R2 /AI7688H/MDI_TN_P3 +3V3 10K
SW2 /AI7688H/JTCLK_GPIO_40 GND SW_USR2
C25 /AI7688H/PORST_N GND 100nF
SW1 /AI7688H/JTDI_GPIO_42 GND SW_USR1
R31 /AI7688H/JTDI_GPIO_42 +3V3 10K
R30 /AI7688H/JTCLK_GPIO_40 +3V3 10K
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ LED
Q2 Net-_Q2-Pad1_ GND Net-_D8-Pad1_ LMBT3904
R34 Net-_D8-Pad2_ +5V 560R
R33 /AI7688H/JTMS_GPIO_41 Net-_Q2-Pad1_ 2.2K
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ LED
Q1 Net-_Q1-Pad1_ GND Net-_D5-Pad1_ LMBT3904
R28 Net-_D5-Pad2_ +5V 560R
R27 /AI7688H/JRST_GPIO_39 Net-_Q1-Pad1_ 2.2K
R29 Net-_D6-Pad2_ +3V3 560R
D6 GND Net-_D6-Pad2_ LED
D7 /AI7688H/WLED_N Net-_D7-Pad2_ LED
R32 +3V3 Net-_D7-Pad2_ 330R
R1 /AI7688H/MDI_RP_P4 Net-_C8-Pad2_ 22R
C8 GND Net-_C8-Pad2_ NC
R17 /AI7688H/EJTAG_DINT +3V3 10K
R18 /AI7688H/JTCLK_GPIO_40 +3V3 1K
R19 /AI7688H/JTMS_GPIO_41 +3V3 1K
R20 /AI7688H/EPHY_LED0_N +3V3 1K
R24 /AI7688H/JTDO_EPHY_LED0_N /AI7688H/EPHY_LED0_N 22R
R22 GND /AI7688H/JRST_GPIO_39 1K
R15 /AI7688H/UART_7688_TXD1 +3V3 4.7K
R16 GND /AI7688H/UART_7688_TXD1 DNP
C19 GND /AI7688H/RF DNP
R23 Net-_C20-Pad2_ /AI7688H/RF 0R
C20 GND Net-_C20-Pad2_ DNP
J1 Net-_C20-Pad2_ GND GND GND GND CONN_SMA
SW4 /AI7688H/WDT_RST_N GND WIFI_RESET
C26 /AI7688H/WDT_RST_N GND 100nF
R25 GND Net-_C27-Pad1_ 10.5k
R26 Net-_C27-Pad1_ +3V3 33K
R13 /AI7688H/MDI_TN_P2 Net-_R13-Pad2_ 22R
R14 /AI7688H/MDI_TP_P2 Net-_R14-Pad2_ 22R
MH1 NC_04 MH_32.8MM
MH2 NC_05 MH_32.8MM
MH3 NC_06 MH_32.8MM
MH4 NC_07 MH_32.8MM
P9 +5V GND GND CONN-PWR-JACK
D9 +5V +5V_USBOTG D_SS24
P8 /AI7688H/EJTAG_DINT /AI7688H/EJTAG_PORST_N /AI7688H/JTCLK_GPIO_40 /AI7688H/JTMS_GPIO_41 /AI7688H/EPHY_LED0_N /AI7688H/JTDI_GPIO_42 /AI7688H/JRST_GPIO_39 +3V3 +3V3 GND CONN_02X05
P4 +5V +3V3 GND /AI7688H/I2C_SD /AI7688H/I2C_SCLK /AI7688H/I2S_SCLK /AI7688H/I2S_WS /AI7688H/I2S_SDO /AI7688H/I2S_SDI /AI7688H/UART_7688_RXD1 /AI7688H/UART_7688_TXD1 /AI7688H/JRST_GPIO_39 /AI7688H/JTDO_EPHY_LED0_N /AI7688H/JTMS_GPIO_41 CONN_01X14
P7 +5V +3V3 GND /AI7688H/WLED_N /AI7688H/REF_CLKO /AI7688H/PERST_N /AI7688H/WDT_RST_N /AI7688H/PORST_N /AI7688H/PCIE_TX0_P /AI7688H/PCIE_TX0_N /AI7688H/PCIE_RX0_P /AI7688H/PCIE_RX0_N /AI7688H/PCIE_CK0_N /AI7688H/PCIE_CK0_P /AI7688H/JTCLK_GPIO_40 /AI7688H/JTDI_GPIO_42 CONN_01X16
P5 +5V +3V3 GND /AI7688H/MDI_TP_P1 /AI7688H/MDI_TN_P1 /AI7688H/MDI_RP_P1 /AI7688H/MDI_RN_P1 /AI7688H/MDI_RP_P2 /AI7688H/MDI_RN_P2 /AI7688H/MDI_TP_P2 /AI7688H/MDI_TN_P2 GND CONN_01X12
P6 GND /AI7688H/UART_7688_TXD0 /AI7688H/UART_7688_RXD0 /AI7688H/GPIO_0 CONN_01X04
R21 /AI7688H/EJTAG_PORST_N /AI7688H/PORST_N 22R
U1 NC_08 NC_09 GND /AI7688H/D+ /AI7688H/D- +3V3 +3V3 +5V_USBOTG NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 Net-_R14-Pad2_ Net-_R13-Pad2_ NC_26 NC_27 GND CP2102
R12 /AI7688H/D+ Net-_D1-Pad1_ 27R
R11 /AI7688H/D- Net-_D2-Pad1_ 27R
C18 GND +3V3 10uF
C21 GND +3V3 100nF
C14 GND +5V_USBOTG 10uF
C15 GND +5V_USBOTG 100nF
P10 +3V3 /AI7688H/MDI_TN_P2 /AI7688H/MDI_TP_P2 GND CONN_01X04
F1 Net-_D10-Pad2_ +5V Fuse
C22 Net-_C22-Pad1_ GND 220uF/16V
C23 GND Net-_C22-Pad1_ 100nF
L1 Net-_C24-Pad2_ +3V3 10uH, 1.5A
C29 GND +3V3 100nF
C28 +3V3 GND 220uF/16V
D12 Net-_D10-Pad2_ GND TVS
D10 Net-_C22-Pad1_ Net-_D10-Pad2_ D_SS24
D11 Net-_C24-Pad2_ GND D_SS24
U3 Net-_C24-Pad1_ GND Net-_C27-Pad1_ Net-_R5-Pad2_ Net-_C22-Pad1_ Net-_C24-Pad2_ LM2734Y
C24 Net-_C24-Pad1_ Net-_C24-Pad2_ 100nF
D13 Net-_C24-Pad1_ +3V3 D_SS24
C27 Net-_C27-Pad1_ +3V3 100nF
R5 Net-_C22-Pad1_ Net-_R5-Pad2_ 100k
.end
