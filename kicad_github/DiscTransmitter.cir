.title KiCad schematic
R1 Net-_R1-Pad1_ Net-_R1-Pad2_ R_Small
R3 Net-_R3-Pad1_ Net-_R3-Pad2_ R_Small
R5 Net-_R5-Pad1_ Net-_R5-Pad2_ R_Small
R7 Net-_R7-Pad1_ Net-_R7-Pad2_ R_Small
R17 Net-_R17-Pad1_ Net-_R17-Pad2_ R_Small
R19 Net-_R19-Pad1_ Net-_R19-Pad2_ R_Small
R21 Net-_R21-Pad1_ Net-_R21-Pad2_ R_Small
R11 Net-_R11-Pad1_ Net-_R11-Pad2_ R_Small
R13 Net-_R13-Pad1_ Net-_R13-Pad2_ R_Small
R15 Net-_R15-Pad1_ Net-_R15-Pad2_ R_Small
R23 Net-_R23-Pad1_ Net-_R23-Pad2_ R_Small
R27 Net-_R27-Pad1_ Net-_R27-Pad2_ R_Small
R29 Net-_R29-Pad1_ Net-_R29-Pad2_ R_Small
R31 Net-_R31-Pad1_ Net-_R31-Pad2_ R_Small
R32 Net-_R32-Pad1_ Net-_R32-Pad2_ R_Small
R30 Net-_R30-Pad1_ Net-_R30-Pad2_ R_Small
R28 Net-_R28-Pad1_ Net-_R28-Pad2_ R_Small
R26 Net-_R26-Pad1_ Net-_R26-Pad2_ R_Small
R9 Net-_R9-Pad1_ Net-_R9-Pad2_ R_Small
R14 Net-_R14-Pad1_ Net-_R14-Pad2_ R_Small
R12 Net-_R12-Pad1_ Net-_R12-Pad2_ R_Small
R10 Net-_R10-Pad1_ Net-_R10-Pad2_ R_Small
R16 Net-_R16-Pad1_ Net-_R16-Pad2_ R_Small
R25 Net-_R25-Pad1_ Net-_R25-Pad2_ R_Small
R24 Net-_R24-Pad1_ Net-_R24-Pad2_ R_Small
R22 Net-_R22-Pad1_ Net-_R22-Pad2_ R_Small
R20 Net-_R20-Pad1_ Net-_R20-Pad2_ R_Small
R18 Net-_R18-Pad1_ Net-_R18-Pad2_ R_Small
R8 Net-_R8-Pad1_ Net-_R8-Pad2_ R_Small
R6 Net-_R6-Pad1_ Net-_R6-Pad2_ R_Small
R4 Net-_R4-Pad1_ Net-_R4-Pad2_ R_Small
R2 Net-_R2-Pad1_ Net-_R2-Pad2_ R_Small
U1 Net-_R31-Pad1_ Net-_R30-Pad2_ Net-_R26-Pad2_ Net-_R25-Pad2_ Net-_R27-Pad1_ Net-_R28-Pad2_ Net-_R32-Pad2_ GND NC_01 Net-_J2-Pad1_ Net-_J3-Pad4_ Net-_J4-Pad1_ Net-_J1-Pad1_ Net-_U1-Pad14_ Net-_R29-Pad1_ +5V SNx4HC595_8b_Shift_Reg
U3 Net-_R23-Pad1_ Net-_R22-Pad2_ Net-_R20-Pad2_ Net-_R18-Pad2_ Net-_R17-Pad1_ Net-_R19-Pad1_ Net-_R24-Pad2_ GND Net-_U1-Pad14_ Net-_J2-Pad1_ Net-_J3-Pad4_ Net-_J4-Pad1_ Net-_J1-Pad1_ Net-_U3-Pad14_ Net-_R21-Pad1_ +5V SNx4HC595_8b_Shift_Reg
U4 Net-_R15-Pad1_ Net-_R12-Pad2_ Net-_R10-Pad2_ Net-_R9-Pad2_ Net-_R11-Pad1_ Net-_R14-Pad2_ Net-_R16-Pad2_ GND Net-_U3-Pad14_ Net-_J2-Pad1_ Net-_J3-Pad4_ Net-_J4-Pad1_ Net-_J1-Pad1_ Net-_U4-Pad14_ Net-_R13-Pad1_ +5V SNx4HC595_8b_Shift_Reg
U5 Net-_R7-Pad1_ Net-_R6-Pad2_ Net-_R4-Pad2_ Net-_R2-Pad2_ Net-_R1-Pad1_ Net-_R3-Pad1_ Net-_R8-Pad2_ GND Net-_U4-Pad14_ Net-_J2-Pad1_ Net-_J3-Pad4_ Net-_J4-Pad1_ Net-_J1-Pad1_ Net-_J3-Pad3_ Net-_R5-Pad1_ +5V SNx4HC595_8b_Shift_Reg
U2 Net-_R2-Pad1_ Net-_R4-Pad1_ Net-_R6-Pad1_ Net-_R8-Pad1_ Net-_R9-Pad1_ Net-_R10-Pad1_ Net-_R14-Pad1_ Net-_R12-Pad1_ Net-_R16-Pad1_ Net-_R18-Pad1_ Net-_R20-Pad1_ Net-_R22-Pad1_ Net-_R24-Pad1_ Net-_R25-Pad1_ Net-_R26-Pad1_ Net-_R28-Pad1_ Net-_R30-Pad1_ Net-_R32-Pad1_ Net-_R31-Pad2_ Net-_R29-Pad2_ Net-_R27-Pad2_ GND GND Net-_R23-Pad2_ Net-_R21-Pad2_ Net-_R19-Pad2_ Net-_R17-Pad2_ Net-_R15-Pad2_ Net-_R13-Pad2_ Net-_R11-Pad2_ GND GND Net-_R7-Pad2_ Net-_R5-Pad2_ Net-_R3-Pad2_ Net-_R1-Pad2_ 4-DigitSevenSegment
J3 GND +5V Net-_J3-Pad3_ Net-_J3-Pad4_ Conn_01x04_Male
J4 Net-_J4-Pad1_ Conn_01x01_Male
J2 Net-_J2-Pad1_ Conn_01x01_Male
J1 Net-_J1-Pad1_ Conn_01x01_Male
.end
