.title KiCad schematic
U5 Net-_D1-Pad2_ GND Net-_R10-Pad2_ Net-_R9-Pad2_ +3V3 MCP1663
D1 +24V Net-_D1-Pad2_ D_Schottky 40V 1A
L2 Net-_D1-Pad2_ +3V3 10uH
R10 +24V Net-_R10-Pad2_ 1.05M
R11 Net-_R10-Pad2_ GND 56k
C16 +24V GND 4.7uF
C17 +24V GND 4.7uF
C12 +3V3 GND 4.7uF
C11 +3V3 GND 4.7uF
U3 Net-_L1-Pad1_ GND Net-_R7-Pad2_ +BATT +3V3 +BATT MP3120
C5 +BATT GND 4.7uF
C2 +BATT GND 4.7uF
R7 +3V3 Net-_R7-Pad2_ 1M
R8 Net-_R7-Pad2_ GND 640k
C14 +3V3 GND 4.7uF
C15 +3V3 GND 4.7uF
U6 GND +3V3 ENABLE NC_01 NC_02 Net-_R18-Pad2_ B_2 NC_03 NC_04 NC_05 B_1 NC_06 NC_07 NC_08 GND NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 EN_24V IO0 NC_17 NC_18 HEAT_INT2 HEAT_INT1 HEAT_nSleep NC_19 NC_20 /VFD IO/SDA RXD0 TXD0 /VFD IO/SCK IO_RESET GND GND ESP32-WROOM
U4 DTR RTS Net-_C10-Pad1_ TXD0 NC_21 GND NC_22 NC_23 NC_24 NC_25 Net-_R3-Pad1_ Net-_R4-Pad1_ Net-_C10-Pad1_ Net-_C10-Pad1_ VBUS GND NC_26 NC_27 NC_28 RXD0 FT231XS
C13 +3V3 GND 1uF
L1 Net-_L1-Pad1_ +BATT 10uH
J1 VBUS Net-_C4-Pad1_ Net-_C3-Pad1_ NC_29 GND GND USB_B_Micro
R3 Net-_R3-Pad1_ Net-_C3-Pad1_ 27
R4 Net-_R4-Pad1_ Net-_C4-Pad1_ 27
C10 Net-_C10-Pad1_ GND 100nF
C4 Net-_C4-Pad1_ GND 47pF
C3 Net-_C3-Pad1_ GND 47pF
C9 VBUS GND 100nF
C8 VBUS GND 4.7uF
Q1 RTS Net-_Q1-Pad2_ IO0 DTR Net-_Q1-Pad5_ ENABLE MBT3904DW1
R13 Net-_Q1-Pad2_ DTR 10k
R12 RTS Net-_Q1-Pad5_ 10k
R16 +3V3 ENABLE 10k
SW3 GND ENABLE B_RES
C18 ENABLE GND 100nF
R17 +3V3 IO0 10k
SW4 GND IO0 B_0
C1 VBUS GND 4.7uF
C6 +3V3 GND 4.7uF
C7 Net-_C7-Pad1_ GND 470pF
BT1 +BATT GND AA BK-92
R9 EN_24V Net-_R9-Pad2_ 10k
U2 +3V3 Net-_R1-Pad2_ Net-_R2-Pad2_ GND HEAT_INT2 HEAT_INT1 Net-_R6-Pad2_ +3V3 GND DRV8837C
R1 /VFD IO/HEAT1 Net-_R1-Pad2_ 0R
R2 /VFD IO/HEAT2 Net-_R2-Pad2_ 0R
R6 HEAT_nSleep Net-_R6-Pad2_ 10k
SW1 GND B_1 B1
SW2 GND B_2 B2
R14 +3V3 B_1 10k
R15 +3V3 B_2 10k
U1 VBUS GND VBUS Net-_C7-Pad1_ +3V3 MIC5219-3.3YM5
J2 GND /VFD IO/SDA /VFD IO/SCK +3V3 I2C_Con
C19 +3V3 GND 10uF
R18 +BATT Net-_R18-Pad2_ 10k
R19 Net-_R18-Pad2_ GND 10k
U10 /VFD IO/HEAT1 /VFD IO/HSS_08 /VFD IO/HSS_07 /VFD IO/HSS_06 /VFD IO/HSS_05 /VFD IO/HSS_04 /VFD IO/HSS_03 /VFD IO/HSS_02 /VFD IO/HSS_01 /VFD IO/HSS_14 /VFD IO/HSS_13 /VFD IO/HSS_12 /VFD IO/HSS_11 /VFD IO/HSS_10 /VFD IO/HSS_09 /VFD IO/HEAT2 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 IVL2-7_5
U8 /VFD IO/GPB7 /VFD IO/GPB6 /VFD IO/GPB5 /VFD IO/GPB4 /VFD IO/GPB3 /VFD IO/GPB2 /VFD IO/GPB1 /VFD IO/GPB0 +24V GND /VFD IO/HSS_08 /VFD IO/HSS_07 /VFD IO/HSS_06 /VFD IO/HSS_05 /VFD IO/HSS_04 /VFD IO/HSS_03 /VFD IO/HSS_02 /VFD IO/HSS_01 TBD62783A
U9 /VFD IO/GPA5 /VFD IO/GPA4 /VFD IO/GPA3 /VFD IO/GPA2 /VFD IO/GPA1 /VFD IO/GPA0 NC_37 NC_38 +24V GND NC_39 NC_40 /VFD IO/HSS_14 /VFD IO/HSS_13 /VFD IO/HSS_12 /VFD IO/HSS_11 /VFD IO/HSS_10 /VFD IO/HSS_09 TBD62783A
U7 /VFD IO/GPB0 /VFD IO/GPB1 /VFD IO/GPB2 /VFD IO/GPB3 /VFD IO/GPB4 /VFD IO/GPB5 /VFD IO/GPB6 /VFD IO/GPB7 +3V3 GND NC_41 /VFD IO/SCK /VFD IO/SDA NC_42 GND GND GND IO_RESET NC_43 NC_44 /VFD IO/GPA0 /VFD IO/GPA1 /VFD IO/GPA2 /VFD IO/GPA3 /VFD IO/GPA4 /VFD IO/GPA5 NC_45 NC_46 MCP23017_SS
R5 +3V3 IO_RESET 10k
.end
