.title KiCad schematic
U1 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 LM13700
U4 NC_17 NC_18 NC_19 +12V Net-_C6-Pad2_ Net-_C5-Pad2_ Net-_C5-Pad1_ Net-_R30-Pad1_ Net-_R28-Pad1_ Net-_C9-Pad1_ -12V GND Net-_R38-Pad1_ RA TL074
U2 Net-_R11-Pad1_ Net-_R1-Pad1_ GND NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 TL074
U5 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 TL072
R31 NC_39 NC_40 R_US
C8 NC_41 NC_42 CP1_Small
Q4 NC_43 NC_44 NC_45 2N3904
RV7 NC_46 NC_47 NC_48 R_POT_US
RV1 CO1 CO2 CO3 100k
R4 -12V CO1 33k
R7 Net-_R13-Pad2_ CO2 100k
R5 +12V CO3 33k
U3 Net-_R13-Pad1_ Net-_R13-Pad2_ GND -12V GND Net-_C4-Pad2_ Net-_C4-Pad1_ +12V TL072
R8 Net-_R13-Pad2_ NC_49 100k
R6 Net-_R13-Pad2_ NC_50 100k
R9 Net-_R13-Pad2_ NC_51 100k
R13 Net-_R13-Pad1_ Net-_R13-Pad2_ 100k
RV5 Net-_R13-Pad1_ Net-_D1-Pad2_ Net-_R14-Pad2_ 100
R14 GND Net-_R14-Pad2_ 100k
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ 1N914
R16 Net-_R16-Pad1_ Net-_D1-Pad1_ 10k
RV6 Net-_C4-Pad1_ Net-_C4-Pad1_ Net-_R16-Pad1_ 100k
R17 Net-_Q1-Pad1_ Net-_C4-Pad1_ 10k
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 100pf
Q2 Net-_Q1-Pad1_ Net-_Q2-Pad2_ GND 2N3904
Q1 Net-_Q1-Pad1_ Net-_C4-Pad2_ Net-_D1-Pad2_ 2N3904
R15 Net-_C4-Pad2_ +12V 1m
D2 NC_52 NC_53 1N914
Q3 NC_54 NC_55 NC_56 2N3906
Q5 GND Net-_Q2-Pad2_ Net-_Q5-Pad3_ 2N3906
Q6 GND Net-_Q2-Pad2_ Net-_Q6-Pad3_ 2N3906
R41 Net-_R41-Pad1_ Net-_Q6-Pad3_ 7.5k
U6 Net-_R41-Pad1_ Net-_R36-Pad1_ GND Net-_R34-Pad2_ Net-_C10-Pad1_ -12V NC_57 NC_58 NC_59 NC_60 +12V Net-_C7-Pad1_ Net-_R22-Pad1_ GND Net-_R26-Pad1_ Net-_R32-Pad2_ LM13700
R32 Net-_Q5-Pad3_ Net-_R32-Pad2_ 7.5k
R36 Net-_R36-Pad1_ +12V 20k
R26 Net-_R26-Pad1_ +12V 20k
U7 Net-_C9-Pad2_ Net-_C9-Pad2_ Net-_C10-Pad1_ -12V Net-_C7-Pad1_ Net-_C6-Pad1_ Net-_C6-Pad1_ +12V TL072
R24 Net-_R22-Pad1_ Net-_R11-Pad1_ 100k
R35 Net-_R34-Pad2_ Net-_C6-Pad1_ 100k
R29 Net-_C6-Pad1_ Net-_R22-Pad1_ 100k
C7 Net-_C7-Pad1_ GND 220pf
R27 GND Net-_R22-Pad1_ 100
R22 Net-_R22-Pad1_ NC_61 150k
R23 -12V Net-_R22-Pad1_ 43k
C6 Net-_C6-Pad1_ Net-_C6-Pad2_ 0.1uf
R39 Net-_C9-Pad2_ Net-_R34-Pad2_ 100k
C10 Net-_C10-Pad1_ GND 220pf
R37 GND Net-_R34-Pad2_ 100
R34 -12V Net-_R34-Pad2_ 39k
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 0.1uf
R2 Net-_R1-Pad1_ Net-_C2-Pad1_ 1m
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 0.1uf
J2 GND GND Net-_J2-Pad3_ PJ301M-12
RV3 GND Net-_C2-Pad2_ Net-_J2-Pad3_ 100k
R3 Net-_R1-Pad1_ Net-_C3-Pad1_ 1m
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 0.1uf
J3 GND GND Net-_J3-Pad3_ PJ301M-12
RV4 GND Net-_C3-Pad2_ Net-_J3-Pad3_ 100k
R1 Net-_R1-Pad1_ Net-_C1-Pad1_ 1m
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 0.1uf
J1 GND GND Net-_J1-Pad3_ PJ301M-12
RV2 GND Net-_C1-Pad2_ Net-_J1-Pad3_ 100k
R12 Net-_R11-Pad1_ Net-_J4-Pad3_ 2k
J4 GND GND Net-_J4-Pad3_ PJ301M-12
R11 Net-_R11-Pad1_ Net-_R1-Pad1_ 3k
R10 Net-_C9-Pad2_ Net-_R1-Pad1_ 49.9k
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 22pf
R20 Net-_C5-Pad1_ Net-_C5-Pad2_ 150k
R21 Net-_J5-Pad3_ Net-_C5-Pad1_ 2k
R19 Net-_C5-Pad2_ GND 180k
R18 GND Net-_C6-Pad2_ 4.7m
J5 GND GND Net-_J5-Pad3_ PJ301M-12
R33 Net-_J6-Pad3_ Net-_R30-Pad1_ 2k
R30 Net-_R30-Pad1_ Net-_R28-Pad1_ 150k
R28 Net-_R28-Pad1_ GND 39k
R25 GND Net-_C9-Pad1_ 4.7m
J6 GND GND Net-_J6-Pad3_ PJ301M-12
R40 RA Net-_R38-Pad1_ 150k
R38 Net-_R38-Pad1_ Net-_C5-Pad1_ 49.9
.end
