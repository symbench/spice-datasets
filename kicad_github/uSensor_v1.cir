.title KiCad schematic
R3 Net-_R3-Pad1_ Net-_R1-Pad1_ 10k 1%
R1 Net-_R1-Pad1_ +5V 220k 1%
R5 Net-_J3-Pad3_ GNDA 100R 1%
R2 Net-_R1-Pad1_ GNDA 220R 1%
R4 Net-_R3-Pad1_ Net-_C1-Pad2_ 22k 1%
C19 +5V GNDA 100n 16V X5R
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 1n 16V X5R
Q2 Net-_C1-Pad1_ Net-_Q2-Pad2_ +5V BC817-25
J4 +3V3 Net-_J4-Pad2_ GNDD Net-_J4-Pad4_ Net-_J4-Pad5_ Net-_J4-Pad6_ UC_DEBUG_RX UC_DEBUG_TX NS25-W8P 8-pin 2,54mm
R17 PROG_SWO Net-_J4-Pad6_ 22R
R16 PROG_~RST Net-_J4-Pad5_ 22R
R15 PROG_SWDIO Net-_J4-Pad4_ 22R
R14 PROG_SWCLK Net-_J4-Pad2_ 22R
C28 GNDD +3V3 4u7 16V X7R
C36 Net-_C36-Pad1_ GNDD 4u7 16V X7R
C35 Net-_C35-Pad1_ GNDD 4u7 16V X7R
R18 Net-_R18-Pad1_ GNDD 390k
C25 Net-_C25-Pad1_ Net-_C25-Pad2_ 1u 16V X5R
C26 Net-_C26-Pad1_ Net-_C26-Pad2_ 1u 16V X5R
C27 GNDD +3V3 4u7 16V X7R
U9 NC_01 Net-_C25-Pad2_ Net-_C25-Pad1_ Net-_C26-Pad2_ Net-_C26-Pad1_ +3V3 NC_02 GNDD +3V3 GNDD GNDD GNDD LCD_CS LCD_RST LCD_A0 GNDD GNDD LCD_SCK LCD_SI GNDD GNDD GNDD GNDD GNDD GNDD Net-_R18-Pad1_ Net-_C36-Pad1_ Net-_C35-Pad1_ GNDD NC_03 UG-2864KSWLG01
SW1 Net-_R21-Pad1_ GNDD SW_Push
R21 Net-_R21-Pad1_ SWITCH_1 470R
C37 SWITCH_1 GNDD 100n 16V X5R
R20 +3V3 SWITCH_1 3k3
SW2 Net-_R23-Pad1_ GNDD SW_Push
R23 Net-_R23-Pad1_ SWITCH_2 470R
C40 SWITCH_2 GNDD 100n 16V X5R
R22 +3V3 SWITCH_2 3k3
R19 Net-_R19-Pad1_ GNDA 100R TBD
U4 +5V TEMP_SENS_OUT_2 GNDA MCP9700AT
C21 +5V GNDA 100n 16V X5R
U7 +5V TEMP_SENS_OUT_1 GNDA MCP9700AT
C23 +5V GNDA 100n 16V X5R
U5 +5V TEMP_SENS_OUT_3 GNDA MCP9700AT
C22 +5V GNDA 100n 16V X5R
U8 +5V TEMP_SENS_OUT_4 GNDA MCP9700AT
C24 +5V GNDA 100n 16V X5R
R30 Net-_R26-Pad1_ /SENS_IN_AMP_CH_A_B/SENS_OUT_1 10k 1%
R32 Net-_R26-Pad1_ /SENS_IN_AMP_CH_C_D/SENS_OUT_1 10k 1%
R28 Net-_R27-Pad1_ /SENS_IN_AMP_CH_C_D/SENS_OUT_2 10k 1%
R27 Net-_R27-Pad1_ /SENS_IN_AMP_CH_A_B/SENS_OUT_2 10k 1%
R33 GNDA Net-_R27-Pad1_ 150k 1%
R31 Net-_R31-Pad1_ FOC_ERR_2_ADC 51R 1%
R29 Net-_R26-Pad2_ Net-_C43-Pad2_ 150k 1%
C43 GNDA Net-_C43-Pad2_ 150p
R26 Net-_R26-Pad1_ Net-_R26-Pad2_ 150k 1%
C45 +5V GNDA 100n 16V X5R
C41 -5V GNDA 100n 16V X5R
U15 NC_04 +5V +5V GNDA NC_05 REF_2.5V NC_06 NC_07 REF192
C47 +5V GNDA 100n 16V X5R
U1 Net-_R6-Pad1_ Net-_C11-Pad2_ Net-_C11-Pad2_ GNDA Net-_C14-Pad2_ Net-_C9-Pad1_ GNDA Net-_C12-Pad1_ Net-_C12-Pad1_ AM10TW-2405DZ
J1 Net-_D1-Pad2_ Net-_C11-Pad2_ +12V Supply
C11 Net-_C11-Pad1_ Net-_C11-Pad2_ 2u2 50V X5R
C12 Net-_C12-Pad1_ Net-_C11-Pad2_ 2u2 50V X5R
L2 Net-_C11-Pad1_ Net-_C12-Pad1_ 12u / min 0.83A
L3 Net-_C14-Pad2_ -5V 82n 1A
L1 Net-_C9-Pad1_ +5V 82n 1A
D4 GNDA -5V TVS 7V
C15 GNDA -5V 22u 50V
C14 GNDA Net-_C14-Pad2_ 1u 50V X5R
D2 +5V GNDA TVS 7V
C10 +5V GNDA 22u 50V
C9 Net-_C9-Pad1_ GNDA 1u 50V X5R
D1 Net-_C11-Pad1_ Net-_D1-Pad2_ 40V 2A
R6 Net-_R6-Pad1_ GNDA 0R
RV1 +5V Net-_RV1-Pad2_ GNDA 10k
C29 +5V GNDA 100n 16V X5R
C30 REF_2.5V GNDA 10n 6V3 X5R
J2 SENS_LD_PWR SENS_LD Net-_J2-Pad3_ Conn_01x03
J3 SENS_PD_ADC SENS_PD Net-_J3-Pad3_ Conn_01x03
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ +5V BC817-25
R8 Net-_Q1-Pad1_ DAC_LD_CTRL 1k
R11 GNDA Net-_Q1-Pad1_ 100k
D3 Net-_C11-Pad1_ Net-_C11-Pad2_ TVS 40V
U10 REF_2.5V +5V Net-_TP34-Pad1_ SENS_D SENS_A SENS_B SENS_C Net-_TP45-Pad1_ GNDA Net-_C42-Pad1_ Net-_R19-Pad1_ SENS_PD Net-_CS1-Pad2_ Net-_CS2-Pad2_ COIL_T- COIL_F- KSS-213 Connector
U12 DAC_OUT_COIL_F_CTRL DAC_OUT_COIL_T_CTRL GNDA DAC_~LDAC DAC_~CLR DAC_ADDR DAC_SCL DAC_SDA Net-_C38-Pad1_ REF_2.5V AD5667
C39 Net-_C38-Pad1_ GNDA 100n 16V X5R
C38 Net-_C38-Pad1_ GNDA 10u 10V X5R
U11 ADC_SCLK Net-_TP99-Pad1_ ADC_~CS NC_08 Net-_C72-Pad1_ GNDA Net-_C71-Pad1_ GNDA Net-_C46-Pad1_ GNDA Net-_C68-Pad1_ GNDA REF_2.5V GNDA Net-_C70-Pad1_ GNDA Net-_C69-Pad1_ GNDA NC_09 GNDA +5V +3V3 ADC_DOUT ADC_DIN AD7795
C31 +5V GNDA 10u 6V3 Tantal
C32 +5V GNDA 100n 16V X5R
C34 +3V3 GNDD 10u 6V3 Tantal
C33 +3V3 GNDD 100n 16V X5R
R25 USB_D- Net-_J5-Pad2_ 22R
R24 USB_D+ Net-_J5-Pad3_ 22R
C67 Net-_C67-Pad1_ GNDD 2u2 6V3 X5R
C20 Net-_C20-Pad1_ GNDD 2u2 6V3 X5R
C6 +3V3 GNDD 100n 16V X5R
C5 +3V3 GNDD 100n 16V X5R
C4 +3V3 GNDD 100n 16V X5R
C7 +3V3 GNDD 100n 16V X5R
C8 +3V3 GNDD 100n 16V X5R
C13 +3V3 GNDD 100n 16V X5R
R7 Net-_R7-Pad1_ GNDD 10k
C17 +3V3 GNDD 1u 16V X5R
R9 Net-_R9-Pad1_ Net-_D5-Pad2_ 100R
R10 Net-_R10-Pad1_ Net-_D6-Pad2_ 100R
D5 GNDD Net-_D5-Pad2_ LED
D6 GNDD Net-_D6-Pad2_ LED
U3 NC_10 NC_11 NC_12 NC_13 NC_14 +3V3 NC_15 NC_16 NC_17 GNDD +3V3 NC_18 NC_19 PROG_~RST TEMP_SENS_OUT_1 TEMP_SENS_OUT_2 TEMP_SENS_OUT_3 TEMP_SENS_OUT_4 +3V3 GNDA NC_20 Net-_C16-Pad1_ SENS_PD_ADC NC_21 NC_22 NC_23 GNDD +3V3 DAC_LD_CTRL NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 LCD_SCK NC_41 Net-_C20-Pad1_ +3V3 LCD_CS LCD_RST LCD_A0 LCD_SI UC_DEBUG_TX UC_DEBUG_RX NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 USB_VBUS NC_53 USB_D- USB_D+ PROG_SWDIO Net-_C67-Pad1_ GNDD +3V3 PROG_SWCLK ADC_~CS ADC_SCLK ADC_DOUT ADC_DIN SWITCH_1 SWITCH_2 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 PROG_SWO NC_60 DAC_ADDR DAC_~CLR DAC_~LDAC Net-_R7-Pad1_ DAC_SCL DAC_SDA Net-_R9-Pad1_ Net-_R10-Pad1_ GNDD +3V3 STM32F407VGTx
U2 GNDD +3V3 +5V LD1117A
C3 +3V3 GNDD 10u 10V X5R
C2 +5V GNDD 100n 16V X5R
R12 Net-_Q2-Pad2_ Net-_J2-Pad3_ 0R
R13 Net-_Q1-Pad2_ SENS_LD_PWR 0R
U6 Net-_R3-Pad1_ Net-_R1-Pad1_ Net-_J3-Pad3_ GNDA Net-_RV1-Pad2_ Net-_C1-Pad2_ Net-_C1-Pad1_ +5V LM6132A
U22 USB_D+ GNDD USB_D- USB_VBUS +5V NC_61 RCLAMP
J5 USB_VBUS Net-_J5-Pad2_ Net-_J5-Pad3_ GNDD GNDD USB_B
RV2 Net-_R65-Pad1_ Net-_R66-Pad2_ Net-_R64-Pad1_ 10k
R65 Net-_R65-Pad1_ +5V 22k
R64 Net-_R64-Pad1_ -5V 22k
U13 Net-_R26-Pad2_ Net-_R26-Pad1_ Net-_R27-Pad1_ -5V Net-_C43-Pad2_ Net-_R31-Pad1_ Net-_R31-Pad1_ +5V MCP6H02-E/SN
R66 Net-_R26-Pad1_ Net-_R66-Pad2_ 1M
TP3 Net-_D1-Pad2_ TP
TP4 Net-_C11-Pad2_ TP
TP2 +5V TP
TP5 -5V TP
TP1 +3V3 TP
TP15 SWITCH_2 TP
TP17 SWITCH_1 TP
TP23 TEMP_SENS_OUT_1 TP
TP24 TEMP_SENS_OUT_3 TP
TP26 TEMP_SENS_OUT_4 TP
TP25 TEMP_SENS_OUT_2 TP
TP44 SENS_D TP
TP42 SENS_B TP
TP43 SENS_C TP
TP41 SENS_A TP
TP34 Net-_TP34-Pad1_ TP
TP45 Net-_TP45-Pad1_ TP
TP40 SENS_LD TP
TP33 Net-_R19-Pad1_ TP
TP39 SENS_PD TP
TP38 COIL_F+ TP
TP37 COIL_F- TP
TP36 COIL_T- TP
TP35 COIL_T+ TP
TP27 DAC_~LDAC TP
TP28 DAC_~CLR TP
TP29 DAC_SDA TP
TP30 DAC_SCL TP
TP31 DAC_OUT_COIL_T_CTRL TP
TP32 DAC_OUT_COIL_F_CTRL TP
TP49 ADC_DOUT TP
TP48 ADC_DIN TP
TP47 ADC_SCLK TP
TP46 ADC_~CS TP
TP58 FOC_ERR_2_ADC TP
TP6 LCD_CS TP
TP7 LCD_RST TP
TP10 LCD_A0 TP
TP11 LCD_SCK TP
TP14 LCD_SI TP
TP19 Net-_C35-Pad1_ TP
TP18 Net-_C36-Pad1_ TP
TP16 Net-_R18-Pad1_ TP
TP9 Net-_C25-Pad1_ TP
TP13 Net-_C26-Pad1_ TP
TP8 Net-_C25-Pad2_ TP
TP12 Net-_C26-Pad2_ TP
TP59 REF_2.5V TP
TP60 /SENS_IN_AMP_CH_C_D/SENS_OUT_1 TP
TP57 /SENS_IN_AMP_CH_C_D/SENS_OUT_2 TP
TP56 /SENS_IN_AMP_CH_A_B/SENS_OUT_2 TP
TP52 /SENS_IN_AMP_CH_A_B/SENS_OUT_1 TP
TP50 Net-_R26-Pad1_ TP
TP53 Net-_R27-Pad1_ TP
TP51 Net-_R26-Pad2_ TP
TP54 Net-_C43-Pad2_ TP
TP55 Net-_R31-Pad1_ TP
TP77 Net-_R1-Pad1_ TP
TP73 Net-_J3-Pad3_ TP
TP75 Net-_R3-Pad1_ TP
TP74 Net-_RV1-Pad2_ TP
TP78 Net-_C1-Pad2_ TP
TP70 SENS_PD_ADC TP
TP72 DAC_LD_CTRL TP
TP71 SENS_LD_PWR TP
TP76 Net-_C1-Pad1_ TP
TP83 Net-_Q1-Pad1_ TP
TP84 GNDA TP
L4 Net-_CS3-Pad2_ Net-_C42-Pad1_ 10u
C42 Net-_C42-Pad1_ GNDA 10u 10V X5R
C46 Net-_C46-Pad1_ GNDA 100n 16V X5R
R67 SENS_A Net-_C46-Pad1_ 10k
C68 Net-_C68-Pad1_ GNDA 100n 16V X5R
R68 SENS_D Net-_C68-Pad1_ 10k
C69 Net-_C69-Pad1_ GNDA 100n 16V X5R
R69 SENS_PD Net-_C69-Pad1_ 10k
C70 Net-_C70-Pad1_ GNDA 100n 16V X5R
R70 FOC_ERR_2_ADC Net-_C70-Pad1_ 10k
TP20 GNDA TP
TP85 GNDA TP
TP86 GNDA TP
TP87 GNDA TP
TP88 GNDA TP
TP89 GNDA TP
TP90 GNDA TP
TP91 GNDD TP
TP92 GNDD TP
TP93 GNDD TP
TP94 GNDD TP
TP95 GNDD TP
TP96 GNDD TP
TP97 GNDD TP
TP98 GNDD TP
R71 GNDA DAC_~LDAC 10k N.M.
R72 GNDD ADC_~CS 10k N.M.
TP99 Net-_TP99-Pad1_ TP
C71 Net-_C71-Pad1_ GNDA 100n 16V X5R
R73 SENS_B Net-_C71-Pad1_ 10k
C72 Net-_C72-Pad1_ GNDA 100n 16V X5R
R74 SENS_C Net-_C72-Pad1_ 10k
J7 Net-_D1-Pad2_ Net-_C11-Pad2_ Net-_C11-Pad2_ Barrel_Jack_Switch
SW3 PROG_~RST GNDD SW_Push
R75 PROG_~RST +3V3 100k
C18 PROG_~RST GNDD 100n 16V X5R
CS1 COIL_F+ Net-_CS1-Pad2_ Curr_Sens
CS2 COIL_T+ Net-_CS2-Pad2_ Curr_Sens
CS3 SENS_LD Net-_CS3-Pad2_ Curr_Sens
TP21 DAC_ADDR TP
C16 Net-_C16-Pad1_ GNDA 100n 16V X5R
L5 Net-_C16-Pad1_ +3V3 10u
L6 +3V3 Net-_C38-Pad1_ 10u
TP22 Net-_R6-Pad1_ TP
J6 GNDA GNDD GNDA-GNDD Jumper
C54 +5V GNDA 100n 16V X5R
R42 Net-_R39-Pad2_ GNDA 10k 1%
R40 +5V Net-_R39-Pad2_ 10k 1%
R39 COIL_F- Net-_R39-Pad2_ 10k 1%
R41 COIL_F+ Net-_Q3-Pad2_ 10k
R38 +5V Net-_Q3-Pad6_ 1R
R44 Net-_Q3-Pad3_ -5V 1R
R43 GNDA COIL_F- 10R
TP80 Net-_R39-Pad2_ TP
TP79 Net-_Q3-Pad2_ TP
Q3 COIL_F+ Net-_Q3-Pad2_ Net-_Q3-Pad3_ COIL_F+ Net-_Q3-Pad2_ Net-_Q3-Pad6_ BC847PN-7-F
RV3 +5V Net-_R39-Pad2_ GNDA 20k
C57 -5V GNDA 100n 16V X5R
R49 Net-_R46-Pad2_ GNDA 10k 1%
R47 +5V Net-_R46-Pad2_ 10k 1%
R46 COIL_T- Net-_R46-Pad2_ 10k 1%
R48 COIL_T+ Net-_Q4-Pad2_ 10k
R45 +5V Net-_Q4-Pad6_ 1R
R51 Net-_Q4-Pad3_ -5V 1R
R50 GNDA COIL_T- 10R
TP82 Net-_R46-Pad2_ TP
TP81 Net-_Q4-Pad2_ TP
Q4 COIL_T+ Net-_Q4-Pad2_ Net-_Q4-Pad3_ COIL_T+ Net-_Q4-Pad2_ Net-_Q4-Pad6_ BC847PN-7-F
RV4 +5V Net-_R46-Pad2_ GNDA 20k
U14 Net-_Q3-Pad2_ Net-_R39-Pad2_ DAC_OUT_COIL_F_CTRL -5V DAC_OUT_COIL_T_CTRL Net-_R46-Pad2_ Net-_Q4-Pad2_ +5V MCP6H02-E/SN
R52 Net-_R52-Pad1_ REF_2.5V 10k 1%
C49 /SENS_IN_AMP_CH_A_B/SENS_OUT_1 Net-_C49-Pad2_ 1p 16V X5R
R54 GNDA Net-_R52-Pad1_ 22k 1%
R36 Net-_C49-Pad2_ SENS_A 10k 1%
R34 /SENS_IN_AMP_CH_A_B/SENS_OUT_1 Net-_C49-Pad2_ 22k 1%
TP61 Net-_C49-Pad2_ TP
TP63 Net-_R52-Pad1_ TP
R53 Net-_R53-Pad1_ REF_2.5V 10k 1%
C50 /SENS_IN_AMP_CH_A_B/SENS_OUT_2 Net-_C50-Pad2_ 1p 16V X5R
R55 GNDA Net-_R53-Pad1_ 22k 1%
R37 Net-_C50-Pad2_ SENS_B 10k 1%
R35 /SENS_IN_AMP_CH_A_B/SENS_OUT_2 Net-_C50-Pad2_ 22k 1%
C51 +5V GNDA 100n 16V X5R
C52 -5V GNDA 100n 16V X5R
TP62 Net-_C50-Pad2_ TP
TP64 Net-_R53-Pad1_ TP
U16 /SENS_IN_AMP_CH_A_B/SENS_OUT_1 Net-_C49-Pad2_ Net-_R52-Pad1_ -5V Net-_R53-Pad1_ Net-_C50-Pad2_ /SENS_IN_AMP_CH_A_B/SENS_OUT_2 +5V MCP6H02-E/SN
C48 REF_2.5V GNDA 10n 6V3 X5R
C44 REF_2.5V GNDA 10n 6V3 X5R
R60 Net-_R60-Pad1_ REF_2.5V 10k 1%
C53 /SENS_IN_AMP_CH_C_D/SENS_OUT_1 Net-_C53-Pad2_ 1p 16V X5R
R62 GNDA Net-_R60-Pad1_ 22k 1%
R58 Net-_C53-Pad2_ SENS_C 10k 1%
R56 /SENS_IN_AMP_CH_C_D/SENS_OUT_1 Net-_C53-Pad2_ 22k 1%
TP65 Net-_C53-Pad2_ TP
TP67 Net-_R60-Pad1_ TP
R61 Net-_R61-Pad1_ REF_2.5V 10k 1%
C55 /SENS_IN_AMP_CH_C_D/SENS_OUT_2 Net-_C55-Pad2_ 1p 16V X5R
R63 GNDA Net-_R61-Pad1_ 22k 1%
R59 Net-_C55-Pad2_ SENS_D 10k 1%
R57 /SENS_IN_AMP_CH_C_D/SENS_OUT_2 Net-_C55-Pad2_ 22k 1%
C56 +5V GNDA 100n 16V X5R
C58 -5V GNDA 100n 16V X5R
TP66 Net-_C55-Pad2_ TP
TP68 Net-_R61-Pad1_ TP
U17 /SENS_IN_AMP_CH_C_D/SENS_OUT_1 Net-_C53-Pad2_ Net-_R60-Pad1_ -5V Net-_R61-Pad1_ Net-_C55-Pad2_ /SENS_IN_AMP_CH_C_D/SENS_OUT_2 +5V MCP6H02-E/SN
C60 REF_2.5V GNDA 10n 6V3 X5R
C59 REF_2.5V GNDA 10n 6V3 X5R
.end
