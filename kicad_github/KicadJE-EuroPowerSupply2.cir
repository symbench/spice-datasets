.title KiCad schematic
P101 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
P102 -12V -12V GND GND GND GND GND GND +12V +12V +5V +5V CV CV Gate Gate Doepfer_Power_16pin
P105 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
P106 -12V -12V GND GND GND GND GND GND +12V +12V +5V +5V CV CV Gate Gate Doepfer_Power_16pin
F101 Net-_F101-Pad1_ Net-_D101-Pad4_ 750mA
RV101 Net-_D101-Pad4_ /DCSleeve Varistor
J103 -12V GND +12V +-12v out
C114 -12V GND 100n
C102 GND +12V 100n
C113 +5V GND 100n
C112 +5V GND 100n
C115 -12V GND 100n
C103 GND +12V 100n
C116 -12V GND 100n
C104 GND +12V 100n
C117 -12V GND 100n
C105 GND +12V 100n
R105 -12V Net-_D106-Pad1_ 4k7
D106 Net-_D106-Pad1_ GND LED
R103 GND Net-_D104-Pad1_ 4k7
D104 Net-_D104-Pad1_ +12V LED
R104 +5V Net-_D105-Pad2_ 1k5
D105 GND Net-_D105-Pad2_ LED
R102 Vin-Pos19 Net-_D103-Pad2_ 10k
D103 Vin-Neg19 Net-_D103-Pad2_ PWR_IN_LED
D101 Vin-Pos19 Vin-Neg19 /DCSleeve Net-_D101-Pad4_ B125C800DM - DB107
J101 Net-_J101-Pad1_ /DCSleeve Laptop Power
C101 Vin-Pos19 Vin-Neg19 100uF
J102 Net-_F103-Pad1_ VinGND Net-_F102-Pad2_ +-15V thru
F102 Vin+15 Net-_F102-Pad2_ 750mA
F103 Net-_F103-Pad1_ Vin-15 750mA
J105 Net-_F101-Pad1_ /DCSleeve Laptop Power Out
SW101 Net-_F101-Pad1_ Net-_J101-Pad1_ NC_01 SW_SPDT
J104 GND +5V +5V out
R101 Net-_D101-Pad4_ Net-_D102-Pad1_ 10r
D102 Net-_D102-Pad1_ /DCSleeve 27v
J106 Vin-Pos19 Vin-Pos19 Vin-Neg19 Vin-Neg19 FrontInterConnVin
J107 Vin-Pos19 Vin-Pos19 Vin-Neg19 Vin-Neg19 FrontInterConnVin
J108 GND I+12 +12V I+5 +5V I-12 -12V GND Conn_01x08
J109 GND I+12 +12V I+5 +5V I-12 -12V GND Conn_01x08
U201 +15V GND 12Vreg LM7812_TO220
U204 GND -15V -12Vreg LM7912_TO220
C204 +15V GND 1000uF
C212 GND -15V 1000uF
C215 GND -15V 100n
C201 +15V GND 100n
U207 +7.5V GND 5Vreg LM78M05_TO252
U209 GND -15V -12Vreg MC79M12_TO252
U208 +15V GND 12Vreg LM78M12_TO252
D201 +15V 12Vreg 1N4001
D203 -12Vreg -15V 1N4001
F203 -12Vreg Net-_F203-Pad2_ 750mA
F201 12Vreg Net-_F201-Pad2_ 750mA
U205 Vin-Neg19 Vin-Pos19 Vin-15 DCDC+ XL6009 Module DCDC 19 to 30v
R205 DCDC+ Net-_D206-Pad2_ 10k
D206 Vin-15 Net-_D206-Pad2_ LED
U202 +7.5V GND 5Vreg LM7805_TO220
C207 +7.5V GND 1000uF
C209 +5V GND 1000uF
C202 +7.5V GND 100n
F202 5Vreg Net-_F202-Pad2_ 750mA
U203 VinGND Net-_R201-Pad1_ /VoltageRegulation/GND-7V /VoltageRegulation/7V Step Down Module +15 to 7v - MP2307
R201 Net-_R201-Pad1_ Vin+15 0R
D202 +7.5V 5Vreg 1N4001
U206 NC_02 VinGND Net-_C216-Pad2_ Vin-15 NC_03 Net-_R206-Pad2_ Vin+15 NC_04 TL071
R204 Vin+15 Net-_C216-Pad2_ 4k70
R207 Net-_C216-Pad2_ Vin-15 4k70
R206 Net-_Q202-Pad1_ Net-_R206-Pad2_ 330r
R202 Net-_C217-Pad1_ Vin+15 10r
R208 Net-_C220-Pad2_ Vin-15 10r
Q202 Net-_Q202-Pad1_ Net-_C217-Pad1_ VinGND TIP41
Q203 Net-_Q202-Pad1_ Net-_C220-Pad2_ VinGND TIP42
C216 Vin+15 Net-_C216-Pad2_ 220n
C218 Net-_C216-Pad2_ Vin-15 220n
C220 VinGND Net-_C220-Pad2_ 220n
C217 Net-_C217-Pad1_ VinGND 220n
C208 5Vreg GND 100n
Q201 Net-_C219-Pad1_ DCDC+ Vin+15 TIP41
R203 DCDC+ Net-_C219-Pad1_ 100r
C219 Net-_C219-Pad1_ Vin-15 1u
D207 Net-_D205-Pad2_ Vin-15 15v
D204 DCDC+ Vin+15 1N4001
D205 Net-_C219-Pad1_ Net-_D205-Pad2_ 15v
C205 /VoltageRegulation/7V /VoltageRegulation/GND-7V 1u
C203 Vin+15 VinGND 1u
C210 VinGND Vin-15 1u
R209 +15V Vin+15 0r25
R211 GND VinGND 0r25
R213 GND VinGND 0r25
R214 -15V Vin-15 0r25
R212 GND /VoltageRegulation/GND-7V 0r25
R210 +7.5V /VoltageRegulation/7V 0r25
C214 GND -12V 1000uF
C206 +12V GND 1000uF
Q204 /VoltageRegulation/b4 Net-_JP201-Pad2_ I+12 MMBT2907A
R219 +12V Net-_F201-Pad2_ 1R1
R220 +12V Net-_F201-Pad2_ 1R1
R215 I+12 Net-_D209-Pad2_ 1k
D209 GND Net-_D209-Pad2_ RED
R221 /VoltageRegulation/b4 +12V 5k6
R222 /VoltageRegulation/b4 GND 100k
R217 +12V Net-_F201-Pad2_ 1R1
R218 +12V Net-_F201-Pad2_ 1R1
R216 I-12 Net-_D208-Pad1_ 1k
D208 Net-_D208-Pad1_ GND RED
Q205 /VoltageRegulation/b5 Net-_JP202-Pad2_ I-12 MMBT2222A
R224 -12V /VoltageRegulation/b5 4k7
R223 GND /VoltageRegulation/b5 100k
R231 +5V Net-_F202-Pad2_ 1R1
R232 +5V Net-_F202-Pad2_ 1R1
R229 +5V Net-_F202-Pad2_ 1R1
R230 +5V Net-_F202-Pad2_ 1R1
R235 Net-_Q206-Pad1_ GND 100k
R234 Net-_Q206-Pad1_ +5V 15k
D210 GND Net-_D210-Pad2_ RED
R233 I+5 Net-_D210-Pad2_ 1k
Q206 Net-_Q206-Pad1_ 5Vreg I+5 MMBT2907A
JP201 12Vreg Net-_JP201-Pad2_ Net-_F201-Pad2_ SolderJumper_3_Bridged12
R227 -12V Net-_F203-Pad2_ 1R1
R228 -12V Net-_F203-Pad2_ 1R1
R225 -12V Net-_F203-Pad2_ 1R1
R226 -12V Net-_F203-Pad2_ 1R1
JP202 -12Vreg Net-_JP202-Pad2_ Net-_F203-Pad2_ SolderJumper_3_Bridged12
.end
