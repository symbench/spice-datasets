.title KiCad schematic
IC1 NC_01 /USART2_TX /USART2_RX NC_02 NC_03 GND Net-_C1-Pad1_ /D+ /D- +3.3V NC_04 NC_05 NC_06 Net-_IC1-Pad14_ Net-_IC1-Pad15_ GND +3.3V /MCLR NC_07 NC_08 /PGED1 /PGEC1 NC_09 NC_10 NC_11 NC_12 NC_13 +3.3V GND NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 GND +3.3V NC_23 +5V NC_24 NC_25 PIC24FJ64GB004
P2 +5V /D- /D+ GND NC_26 SERIAL5_SBDBT
R2 Net-_D1-Pad2_ Net-_IC1-Pad14_ 510
R3 Net-_D2-Pad2_ Net-_IC1-Pad15_ 510
D1 +5V Net-_D1-Pad2_ DATE
D2 +5V Net-_D2-Pad2_ COMM
C1 Net-_C1-Pad1_ GND 1u
R1 /MCLR +3.3V 10k
C2 GND +3.3V 0.1u
C3 GND +3.3V 0.1u
C4 GND +3.3V 0.1u
P1 /MCLR +5V GND /PGED1 /PGEC1 NC_27 PICKit3
U1 /PE2 /PE3 /PE4 /TIM9_CH1 /TIM9_CH2 +3.3V /PC13 /PC14 /PC15 GND +3.3V /OSC_IN /OSC_OUT /NRST /ADC12_IN10 /ADC12_IN11 /SPI2_MISO /SPI2_MOSI +3.3V GND +3.3V +3.3V /TIM5_CH1 /TIM5_CH2 /ADC12_IN2 /ADC12_IN3 GND +3.3V /ADC12_IN4 /ADC12_IN5 /ADC12_IN6 /TIM8_CH1 /ADC12_IN14 /ADC12_IN15 /TIM8_CH2 /ADC12_IN9 /PB2 /PE7 /PE8 /TIM1_CH1 /PE10 /TIM1_CH2 /PE12 /TIM1_CH3 /TIM1_CH4 /PE15 /SPI2_SCK /PB11 Net-_C26-Pad1_ +3.3V /CAN2_RX /CAN2_TX /TIM12_CH1 /TIM12_CH2 /USART3_TX /USART3_RX /PD10 /PD11 /TIM4_CH1 /TIM4_CH2 /PD14 /PD15 /USART6_TX /USART6_RX /TIM8_CH3 /TIM8_CH4 /PA8 /USART1_TX /USART1_RX /CAN1_RX /CAN1_TX /SWDIO Net-_C27-Pad1_ GND +3.3V /SWCLK /TIM2_CH1 /USART4_TX /USART4_RX /UART5_TX /PD0 /PD1 /UART5_RX /PD3 /PD4 /USART2_TX /USART2_RX /PD7 /TIM2_CH2 /TIM3_CH1 /TIM3_CH2 /I2C1_SCL /I2C1_SDA Net-_R25-Pad1_ /TIM10_CH1 /TIM11_CH1 /PE0 /PE1 GND +3.3V STM32F407VG
U2 GND +3.3V +5V AZ1086H
C6 +5V GND 22u
C7 +3.3V GND 10u
C5 /12V_TO_5V GND 0.1u
U5 /CAN1_TX GND +3.3V /CAN1_RX NC_28 /CAN0_L /CAN0_H Net-_R38-Pad2_ MAX3051
U6 /CAN2_TX GND +3.3V /CAN2_RX NC_29 /CAN1_L /CAN1_H Net-_R39-Pad2_ MAX3051
R38 GND Net-_R38-Pad2_ R_JP
R39 GND Net-_R39-Pad2_ R_JP
C20 GND +3.3V 0.1u
C21 GND +3.3V 0.1u
JP1 /CAN0_L Net-_JP1-Pad2_ CAN0_JP
R40 /CAN0_H Net-_JP1-Pad2_ 120
JP2 Net-_JP2-Pad1_ /CAN1_L CAN1_JP
R41 Net-_JP2-Pad1_ /CAN1_H 120
P11 GND CAN0_BUS_Vdd /CAN0_H /CAN0_L CAN0
C22 GND CAN0_BUS_Vdd 1u
P12 GND CAN1_BUS_Vdd /CAN1_H /CAN1_L CAN1
C23 GND CAN1_BUS_Vdd 1u
P10 GND /XA_5V 5V
P5 /BUS_5V /D-_USB /D+_USB NC_30 GND NC_31 SERIAL1
Q1 /XA_5V Net-_D13-Pad2_ /5V P_FET
D12 /XA_5V /5V DIODE
D13 /BUS_5V Net-_D13-Pad2_ DIODE
R33 /XA_5V GND 10k
R25 Net-_R25-Pad1_ GND 10k
P8 GND +5V /UART5_TX /UART5_RX SERIAL4
P9 GND +5V /USART4_TX /USART4_RX SERIAL3
C16 GND +5V 0.1u
C17 GND +5V 0.1u
U3 +3.3V /GP0 /GP1 Net-_R12-Pad1_ /USART3_TX /USART3_RX /GP2 NC_32 NC_33 NC_34 +3.3V /D-_USB /D+_USB GND MCP2221A
R12 Net-_R12-Pad1_ +3.3V 10k
C10 +3.3V GND 0.1u
R22 Net-_D3-Pad2_ /GP0 330
R23 Net-_D4-Pad2_ /GP1 330
R24 Net-_D5-Pad2_ /GP2 330
D3 +3.3V Net-_D3-Pad2_ SERIAL1_RX
D4 +3.3V Net-_D4-Pad2_ SERIAL1_TX
D5 +3.3V Net-_D5-Pad2_ SERIAL1_ACTIVE
P3 GND +5V Net-_P3-Pad3_ Net-_P3-Pad4_ ENC1
C8 GND +5V 0.1u
R4 Net-_P3-Pad3_ /TIM2_CH2 100
R5 Net-_P3-Pad4_ /TIM2_CH1 100
R10 Net-_P3-Pad3_ +3.3V 1k
R8 Net-_P3-Pad4_ +3.3V 1k
P6 GND +5V Net-_P6-Pad3_ Net-_P6-Pad4_ ENC3
C14 GND +5V 0.1u
R13 Net-_P6-Pad3_ /TIM5_CH2 100
R14 Net-_P6-Pad4_ /TIM5_CH1 100
R20 Net-_P6-Pad3_ +3.3V 1k
R18 Net-_P6-Pad4_ +3.3V 1k
P4 GND +5V Net-_P4-Pad3_ Net-_P4-Pad4_ ENC2
C9 GND +5V 0.1u
R6 Net-_P4-Pad3_ /TIM3_CH2 100
R7 Net-_P4-Pad4_ /TIM3_CH1 100
R11 Net-_P4-Pad3_ +3.3V 1k
R9 Net-_P4-Pad4_ +3.3V 1k
P7 GND +5V Net-_P7-Pad3_ Net-_P7-Pad4_ ENC0
C15 GND +5V 0.1u
R15 Net-_P7-Pad3_ /TIM4_CH2 100
R16 Net-_P7-Pad4_ /TIM4_CH1 100
R21 Net-_P7-Pad3_ +3.3V 1k
R19 Net-_P7-Pad4_ +3.3V 1k
X1 /OSC_OUT /OSC_IN 8MHz
C11 /OSC_OUT GND 22p
C13 /OSC_IN GND 22p
LED1 /NRST GND Net-_LED1-Pad3_ GND RESET
C12 /NRST GND 0.1u
R17 /PE12 Net-_LED1-Pad3_ 330
C18 Net-_C18-Pad1_ Net-_C18-Pad2_ 0.1u
C19 Net-_C19-Pad1_ GND 1u
U4 Net-_C18-Pad2_ GND /FB Net-_C19-Pad1_ Net-_C19-Pad1_ Net-_C18-Pad1_ AP3211
L1 Net-_C18-Pad1_ Net-_D15-Pad1_ 22uH
R35 Net-_D15-Pad1_ /FB 50k
R36 /FB GND 10k
D14 GND Net-_C18-Pad1_ DIODE
D15 Net-_D15-Pad1_ /12V_TO_5V DIODE
SW1 +5C Net-_R34-Pad2_ Net-_R32-Pad1_ POWER_ON
Q2 Net-_Q2-Pad1_ +5C +5V P_FET
R34 Net-_Q2-Pad1_ Net-_R34-Pad2_ 10
R32 Net-_R32-Pad1_ GND 10k
Q3 /5V Net-_D17-Pad2_ +5C P_FET
D17 NC_35 Net-_D17-Pad2_ DIODE
R37 /5V GND 10k
D16 /5V +5C DIODE
R26 GND Net-_D6-Pad2_ 510
D6 /XA_5V Net-_D6-Pad2_ SELF_5V
R27 Net-_D7-Pad1_ /BUS_5V 510
D7 Net-_D7-Pad1_ GND BUS_5V
R28 Net-_D8-Pad1_ /12V_TO_5V 510
D8 Net-_D8-Pad1_ GND 12V_to_5V
R29 Net-_D9-Pad1_ +5C 510
D9 Net-_D9-Pad1_ GND SW_5V
R30 Net-_D10-Pad1_ +5V 510
D10 Net-_D10-Pad1_ GND USE_5V
R31 Net-_D11-Pad1_ +3.3V 330
D11 Net-_D11-Pad1_ GND 3.3V
P15 GND +5V /USART6_TX /USART6_RX SERIAL2
P16 GND +5V /USART1_TX /USART1_RX SERIAL0
C24 GND +5V 0.1u
C25 GND +5V 0.1u
U7 NC_36 Net-_C29-Pad1_ Net-_C30-Pad1_ Net-_C30-Pad2_ +3.3V GND /I2C1_SDA /I2C1_SCL +3.3V +3.3V Net-_Q4-Pad3_ AQM1602_BL
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ NPN
R43 Net-_Q4-Pad2_ GND 120
R42 Net-_Q4-Pad1_ /PE10 10
C27 Net-_C27-Pad1_ GND 2.2u
C26 Net-_C26-Pad1_ GND 2.2u
P17 GND +12V 12V
C28 GND +3.3V 0.1u
C30 Net-_C30-Pad1_ Net-_C30-Pad2_ 1u
SW2 GND /PD3 SW1
R45 +3.3V /PD3 10k
D19 /PD10 Net-_D19-Pad2_ LED
R49 Net-_D19-Pad2_ GND 330
U8 /TIM8_CH4 /TIM8_CH3 /TIM12_CH2 Net-_R48-Pad2_ Net-_R47-Pad2_ Net-_R46-Pad2_ OSTBABS4C2B
R46 GND Net-_R46-Pad2_ 330
R47 GND Net-_R47-Pad2_ 330
R48 GND Net-_R48-Pad2_ 330
P14 GND CAN1_BUS_Vdd /CAN1_H /CAN1_L CAN1
P13 GND CAN0_BUS_Vdd /CAN0_H /CAN0_L CAN0
P24 /TIM1_CH4 /TIM1_CH3 /TIM1_CH2 /TIM1_CH1 /TIM8_CH2 /TIM8_CH1 /TIM9_CH2 /TIM9_CH1 /TIM11_CH1 /TIM10_CH1 PWM
P26 +5V GND +5V GND +5V GND +5V GND +5V GND +5V GND +5V GND +5V GND +5V GND +5V GND PWM_batt
SP1 +3.3V Net-_D20-Pad1_ SPEAKER
Q5 Net-_Q5-Pad1_ Net-_Q5-Pad2_ Net-_D20-Pad1_ NPN
R53 Net-_Q5-Pad2_ GND 120
R51 Net-_Q5-Pad1_ /TIM12_CH1 10
D20 Net-_D20-Pad1_ +3.3V DIODE
R44 Net-_D18-Pad1_ +12V 1.2k
D18 Net-_D18-Pad1_ GND 12V
P23 /ADC12_IN9 /ADC12_IN15 /ADC12_IN14 /ADC12_IN6 /ADC12_IN5 /ADC12_IN4 /ADC12_IN3 /ADC12_IN2 /ADC12_IN11 /ADC12_IN10 A/D
P25 +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND +3.3V GND A/D_batt
C29 Net-_C29-Pad1_ +3.3V 1u
R52 +3.3V /I2C1_SCL 10k
R50 +3.3V /I2C1_SDA 10k
P18 GND Net-_JP3-Pad2_ /SWCLK /SWDIO /NRST SWD
JP3 +3.3V Net-_JP3-Pad2_ SWD_3.3V_JP
U11 LOGO
U10 LOGO
U9 LOGO
SW3 GND /PD1 SW0
R54 +3.3V /PD1 10k
SW4 GND /PD4 SW2
R55 +3.3V /PD4 10k
SW5 GND /PD7 SW3
R56 +3.3V /PD7 10k
D21 /PD11 Net-_D21-Pad2_ LED
D22 /PD14 Net-_D22-Pad2_ LED
D23 /PA8 Net-_D23-Pad2_ LED
R57 Net-_D21-Pad2_ GND 330
R58 Net-_D22-Pad2_ GND 330
R59 Net-_D23-Pad2_ GND 330
C34 GND +3.3V 1u
C33 GND +3.3V 0.1u
C35 GND +3.3V 4.7u
C36 GND +3.3V 0.1u
C37 GND +3.3V 0.1u
C38 GND +3.3V 0.1u
C39 GND +3.3V 0.1u
C40 GND +3.3V 0.1u
U12 /PE8 Net-_R62-Pad1_ /PE7 GND Net-_R64-Pad2_ Net-_R63-Pad2_ /PB2 +3.3V 25LC010A
C41 GND +3.3V 0.1u
D24 /PD15 Net-_D24-Pad2_ LED
D25 /PD0 Net-_D25-Pad2_ LED
R60 Net-_D24-Pad2_ GND 330
R61 Net-_D25-Pad2_ GND 330
R62 Net-_R62-Pad1_ /SPI2_MISO 10
R63 /SPI2_SCK Net-_R63-Pad2_ 10
R64 /SPI2_MOSI Net-_R64-Pad2_ 10
P27 GND XA4_12V Net-_D26-Pad2_ /PB11 EMERGENCY_CHECK
C42 GND XA4_12V 0.1u
D26 /PE15 Net-_D26-Pad2_ DIODE
D27 /PB11 +3.3V DIODE
D28 GND /PB11 DIODE
P28 /PC15 /PC14 /PC13 /PE4 I/O_3.3V
P29 /PE3 /PE2 /PE1 /PE0 I/O_5V
P30 +3.3V GND +3.3V GND +3.3V GND +3.3V GND I/O_3.3V_batt
P31 +5V GND +5V GND +5V GND +5V GND I/O_5V_batt
U13 LOGO
D29 +12V Net-_C19-Pad1_ DIODE
D38 CAN0_BUS_Vdd /CAN0_BUS_12V DIODE
R67 Net-_D36-Pad1_ /CAN0_BUS_12V 1.2k
D36 Net-_D36-Pad1_ GND CAN0_BUS
D39 CAN1_BUS_Vdd /CAN1_BUS_12V DIODE
D37 Net-_D37-Pad1_ GND CAN1_BUS
R68 Net-_D37-Pad1_ /CAN1_BUS_12V 1.2k
D30 /XA4-12V +12V DIODE
R66 Net-_D35-Pad1_ /XA4-12V 1.2k
D32 XA4_12V /XA4-12V DIODE
D35 Net-_D35-Pad1_ GND XA4_12V
Q6 /XA4-12V Net-_D31-Pad2_ +12V P_FET
D31 /CAN_BUS_12V Net-_D31-Pad2_ DIODE
R65 /XA4-12V GND 10k
D34 /CAN1_BUS_12V /CAN_BUS_12V DIODE
D33 /CAN0_BUS_12V /CAN_BUS_12V DIODE
.end
