.title KiCad schematic
U1 LED data GND GND NC_01 NC_02 row0 row1 row2 row3 NC_03 NC_04 NC_05 NC_06 col5 col4 col3 col2 col1 col0 VCC reset GND NC_07 ProMicro
RSW1 reset GND SW_PUSH
J1 NC_08 data GND VCC MJ-4PP-9
U2 LED_r data_r GNDA GNDA NC_09 NC_10 row0_r row1_r row2_r row3_r NC_11 NC_12 NC_13 NC_14 col5_r col4_r col3_r col2_r col1_r col0_r VDD reset_r GNDA NC_15 ProMicro
SW23 col1_r Net-_D23-Pad2_ SW_PUSH
D23 row0_r Net-_D23-Pad2_ D
SW24 col2_r Net-_D24-Pad2_ SW_PUSH
D24 row0_r Net-_D24-Pad2_ D
SW25 col3_r Net-_D25-Pad2_ SW_PUSH
SW26 col4_r Net-_D26-Pad2_ SW_PUSH
SW27 col5_r Net-_D27-Pad2_ SW_PUSH
D25 row0_r Net-_D25-Pad2_ D
D26 row0_r Net-_D26-Pad2_ D
D27 row0_r Net-_D27-Pad2_ D
SW22 col0_r Net-_D22-Pad2_ SW_PUSH
D22 row0_r Net-_D22-Pad2_ D
SW29 col1_r Net-_D29-Pad2_ SW_PUSH
D29 row1_r Net-_D29-Pad2_ D
SW30 col2_r Net-_D30-Pad2_ SW_PUSH
D30 row1_r Net-_D30-Pad2_ D
SW31 col3_r Net-_D31-Pad2_ SW_PUSH
SW32 col4_r Net-_D32-Pad2_ SW_PUSH
SW33 col5_r Net-_D33-Pad2_ SW_PUSH
D31 row1_r Net-_D31-Pad2_ D
D32 row1_r Net-_D32-Pad2_ D
SW28 col0_r Net-_D28-Pad2_ SW_PUSH
D28 row1_r Net-_D28-Pad2_ D
SW35 col1_r Net-_D35-Pad2_ SW_PUSH
D35 row2_r Net-_D35-Pad2_ D
D36 row2_r Net-_D36-Pad2_ D
SW37 col3_r Net-_D37-Pad2_ SW_PUSH
SW38 col4_r Net-_D38-Pad2_ SW_PUSH
SW39 col5_r Net-_D39-Pad2_ SW_PUSH
D37 row2_r Net-_D37-Pad2_ D
D38 row2_r Net-_D38-Pad2_ D
D39 row2_r Net-_D39-Pad2_ D
SW34 col0_r Net-_D34-Pad2_ SW_PUSH
D34 row2_r Net-_D34-Pad2_ D
SW41 col4_r Net-_D41-Pad2_ SW_PUSH
D41 row3_r Net-_D41-Pad2_ D
SW42 col5_r Net-_D42-Pad2_ SW_PUSH
D42 row3_r Net-_D42-Pad2_ D
SW40 col3_r Net-_D40-Pad2_ SW_PUSH
RSW2 reset_r GNDA SW_PUSH
J3 NC_16 data_r GNDA VDD MJ-4PP-9
LED7 VCC Net-_LED13-Pad4_ GND Net-_LED7-Pad4_ YS-SK6812MINI-E
LED8 VCC Net-_LED7-Pad4_ GND Net-_LED14-Pad2_ YS-SK6812MINI-E
LED9 VCC Net-_LED15-Pad4_ GND Net-_LED10-Pad2_ YS-SK6812MINI-E
LED10 VCC Net-_LED10-Pad2_ GND Net-_LED10-Pad4_ YS-SK6812MINI-E
LED11 VCC Net-_LED11-Pad2_ GND Net-_LED11-Pad4_ YS-SK6812MINI-E
LED12 VCC Net-_LED11-Pad4_ GND Net-_LED12-Pad4_ YS-SK6812MINI-E
LED14 VCC Net-_LED14-Pad2_ GND Net-_LED14-Pad4_ YS-SK6812MINI-E
LED15 VCC Net-_LED15-Pad2_ GND Net-_LED15-Pad4_ YS-SK6812MINI-E
LED16 VCC Net-_LED10-Pad4_ GND Net-_LED16-Pad4_ YS-SK6812MINI-E
LED17 VCC Net-_LED17-Pad2_ GND Net-_LED11-Pad2_ YS-SK6812MINI-E
LED18 VCC Net-_LED12-Pad4_ GND Net-_LED18-Pad4_ YS-SK6812MINI-E
LED19 VCC Net-_LED19-Pad2_ GND Net-_LED13-Pad2_ YS-SK6812MINI-E
LED20 VCC Net-_LED14-Pad4_ GND Net-_LED20-Pad4_ YS-SK6812MINI-E
LED21 VCC Net-_LED21-Pad2_ GND Net-_LED15-Pad2_ YS-SK6812MINI-E
LED22 VCC Net-_LED16-Pad4_ GND Net-_LED22-Pad4_ YS-SK6812MINI-E
LED23 VCC Net-_LED23-Pad2_ GND Net-_LED17-Pad2_ YS-SK6812MINI-E
LED24 VCC Net-_LED18-Pad4_ GND Net-_LED24-Pad4_ YS-SK6812MINI-E
LED26 VCC Net-_LED25-Pad4_ GND Net-_LED23-Pad2_ YS-SK6812MINI-E
LED27 VCC Net-_LED24-Pad4_ GND Net-_LED27-Pad4_ YS-SK6812MINI-E
LED2 VCC Net-_LED1-Pad4_ GND Net-_LED2-Pad4_ WS2812B
LED5 VCC Net-_LED5-Pad2_ GND Net-_LED4-Pad2_ WS2812B
LED4 VCC Net-_LED4-Pad2_ GND Net-_LED1-Pad2_ WS2812B
LED34 VDD Net-_LED34-Pad2_ GNDA Net-_LED34-Pad4_ YS-SK6812MINI-E
LED35 VDD Net-_LED34-Pad4_ GNDA Net-_LED35-Pad4_ YS-SK6812MINI-E
LED36 VDD Net-_LED36-Pad2_ GNDA Net-_LED36-Pad4_ YS-SK6812MINI-E
LED37 VDD Net-_LED36-Pad4_ GNDA Net-_LED37-Pad4_ YS-SK6812MINI-E
LED38 VDD Net-_LED38-Pad2_ GNDA Net-_LED38-Pad4_ YS-SK6812MINI-E
LED39 VDD Net-_LED38-Pad4_ GNDA Net-_LED39-Pad4_ YS-SK6812MINI-E
LED40 VDD Net-_LED40-Pad2_ GNDA Net-_LED34-Pad2_ YS-SK6812MINI-E
LED41 VDD Net-_LED35-Pad4_ GNDA Net-_LED41-Pad4_ YS-SK6812MINI-E
LED42 VDD Net-_LED42-Pad2_ GNDA Net-_LED36-Pad2_ YS-SK6812MINI-E
LED43 VDD Net-_LED37-Pad4_ GNDA Net-_LED43-Pad4_ YS-SK6812MINI-E
LED44 VDD Net-_LED44-Pad2_ GNDA Net-_LED38-Pad2_ YS-SK6812MINI-E
LED45 VDD Net-_LED39-Pad4_ GNDA Net-_LED45-Pad4_ YS-SK6812MINI-E
LED47 VDD Net-_LED41-Pad4_ GNDA Net-_LED47-Pad4_ YS-SK6812MINI-E
LED48 VDD Net-_LED48-Pad2_ GNDA Net-_LED42-Pad2_ YS-SK6812MINI-E
LED49 VDD Net-_LED43-Pad4_ GNDA Net-_LED49-Pad4_ YS-SK6812MINI-E
LED50 VDD Net-_LED50-Pad2_ GNDA Net-_LED44-Pad2_ YS-SK6812MINI-E
LED51 VDD Net-_LED45-Pad4_ GNDA Net-_LED51-Pad4_ YS-SK6812MINI-E
LED52 VDD Net-_LED49-Pad4_ GNDA Net-_LED52-Pad4_ YS-SK6812MINI-E
SW47 col1_r Net-_D47-Pad2_ SW_PUSH
SW46 col0_r Net-_D46-Pad2_ SW_PUSH
D46 row3_r Net-_D46-Pad2_ D
D40 row3_r Net-_D40-Pad2_ D
D47 row3_r Net-_D47-Pad2_ D
LED55 VCC NC_17 GND Net-_LED19-Pad2_ YS-SK6812MINI-E
LED58 VDD Net-_LED47-Pad4_ GNDA Net-_LED58-Pad4_ YS-SK6812MINI-E
LED57 VDD NC_18 GNDA Net-_LED46-Pad2_ YS-SK6812MINI-E
LED46 VDD Net-_LED46-Pad2_ GNDA Net-_LED40-Pad2_ YS-SK6812MINI-E
LED13 VCC Net-_LED13-Pad2_ GND Net-_LED13-Pad4_ YS-SK6812MINI-E
LED56 VCC Net-_LED20-Pad4_ GND Net-_LED56-Pad4_ YS-SK6812MINI-E
LED25 VCC Net-_LED22-Pad4_ GND Net-_LED25-Pad4_ YS-SK6812MINI-E
LED59 VCC Net-_LED56-Pad4_ GND Net-_LED21-Pad2_ YS-SK6812MINI-E
LED60 VDD Net-_LED58-Pad4_ GNDA Net-_LED48-Pad2_ YS-SK6812MINI-E
D48 row3_r Net-_D48-Pad2_ D
SW48 col2_r Net-_D48-Pad2_ SW_PUSH
SW36 col2_r Net-_D36-Pad2_ SW_PUSH
D33 row1_r Net-_D33-Pad2_ D
SW2 col1 Net-_D2-Pad2_ SW_PUSH
D2 row0 Net-_D2-Pad2_ D
SW3 col2 Net-_D3-Pad2_ SW_PUSH
D3 row0 Net-_D3-Pad2_ D
SW4 col3 Net-_D4-Pad2_ SW_PUSH
SW5 col4 Net-_D5-Pad2_ SW_PUSH
SW6 col5 Net-_D6-Pad2_ SW_PUSH
D4 row0 Net-_D4-Pad2_ D
D5 row0 Net-_D5-Pad2_ D
D6 row0 Net-_D6-Pad2_ D
SW1 col0 Net-_D1-Pad2_ SW_PUSH
D1 row0 Net-_D1-Pad2_ D
SW8 col1 Net-_D8-Pad2_ SW_PUSH
D8 row1 Net-_D8-Pad2_ D
SW9 col2 Net-_D9-Pad2_ SW_PUSH
D9 row1 Net-_D9-Pad2_ D
SW10 col3 Net-_D10-Pad2_ SW_PUSH
SW11 col4 Net-_D11-Pad2_ SW_PUSH
SW12 col5 Net-_D12-Pad2_ SW_PUSH
D10 row1 Net-_D10-Pad2_ D
D11 row1 Net-_D11-Pad2_ D
D12 row1 Net-_D12-Pad2_ D
SW7 col0 Net-_D7-Pad2_ SW_PUSH
D7 row1 Net-_D7-Pad2_ D
D14 row2 Net-_D14-Pad2_ D
D15 row2 Net-_D15-Pad2_ D
SW16 col3 Net-_D16-Pad2_ SW_PUSH
SW17 col4 Net-_D17-Pad2_ SW_PUSH
D16 row2 Net-_D16-Pad2_ D
D17 row2 Net-_D17-Pad2_ D
SW20 col4 Net-_D20-Pad2_ SW_PUSH
D20 row3 Net-_D20-Pad2_ D
SW21 col5 Net-_D21-Pad2_ SW_PUSH
D21 row3 Net-_D21-Pad2_ D
D19 row3 Net-_D19-Pad2_ D
D13 row2 Net-_D13-Pad2_ D
SW13 col0 Net-_D13-Pad2_ SW_PUSH
SW14 col1 Net-_D14-Pad2_ SW_PUSH
D43 row3 Net-_D43-Pad2_ D
SW44 col1 Net-_D44-Pad2_ SW_PUSH
SW43 col0 Net-_D43-Pad2_ SW_PUSH
D44 row3 Net-_D44-Pad2_ D
SW19 col3 Net-_D19-Pad2_ SW_PUSH
SW45 col2 Net-_D45-Pad2_ SW_PUSH
D45 row3 Net-_D45-Pad2_ D
SW15 col2 Net-_D15-Pad2_ SW_PUSH
D18 row2 Net-_D18-Pad2_ D
SW18 col5 Net-_D18-Pad2_ SW_PUSH
LED32 VDD Net-_LED32-Pad2_ GNDA Net-_LED31-Pad2_ WS2812B
LED33 VDD Net-_LED33-Pad2_ GNDA Net-_LED32-Pad2_ WS2812B
LED3 VCC Net-_LED2-Pad4_ GND LED WS2812B
LED1 VCC Net-_LED1-Pad2_ GND Net-_LED1-Pad4_ WS2812B
LED6 VCC Net-_LED27-Pad4_ GND Net-_LED5-Pad2_ WS2812B
LED30 VDD Net-_LED29-Pad4_ GNDA LED_r WS2812B
LED31 VDD Net-_LED31-Pad2_ GNDA Net-_LED28-Pad2_ WS2812B
LED28 VDD Net-_LED28-Pad2_ GNDA Net-_LED28-Pad4_ WS2812B
LED29 VDD Net-_LED28-Pad4_ GNDA Net-_LED29-Pad4_ WS2812B
LED53 VDD Net-_LED52-Pad4_ GNDA Net-_LED50-Pad2_ YS-SK6812MINI-E
LED54 VDD Net-_LED51-Pad4_ GNDA Net-_LED33-Pad2_ YS-SK6812MINI-E
.end
