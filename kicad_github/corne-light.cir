.title KiCad schematic
U1 NC_01 data GND GND SDA SCL row0 row1 row2 row3 NC_02 NC_03 NC_04 NC_05 col5 col4 col3 col2 col1 col0 VCC reset GND NC_06 ProMicro
SW2 col1 Net-_D2-Pad2_ SW_PUSH
D2 row0 Net-_D2-Pad2_ D
SW3 col2 Net-_D3-Pad2_ SW_PUSH
D3 row0 Net-_D3-Pad2_ D
SW4 col3 Net-_D4-Pad2_ SW_PUSH
SW5 col4 Net-_D5-Pad2_ SW_PUSH
SW6 col5 Net-_D6-Pad2_ SW_PUSH
D4 row0 Net-_D4-Pad2_ D
D5 row0 Net-_D5-Pad2_ D
D6 row0 Net-_D6-Pad2_ D
SW1 col0 Net-_D1-Pad2_ SW_PUSH
D1 row0 Net-_D1-Pad2_ D
SW8 col1 Net-_D8-Pad2_ SW_PUSH
D8 row1 Net-_D8-Pad2_ D
SW9 col2 Net-_D9-Pad2_ SW_PUSH
D9 row1 Net-_D9-Pad2_ D
SW10 col3 Net-_D10-Pad2_ SW_PUSH
SW11 col4 Net-_D11-Pad2_ SW_PUSH
SW12 col5 Net-_D12-Pad2_ SW_PUSH
D10 row1 Net-_D10-Pad2_ D
D11 row1 Net-_D11-Pad2_ D
D12 row1 Net-_D12-Pad2_ D
SW7 col0 Net-_D7-Pad2_ SW_PUSH
D7 row1 Net-_D7-Pad2_ D
SW14 col1 Net-_D14-Pad2_ SW_PUSH
D14 row2 Net-_D14-Pad2_ D
SW15 col2 Net-_D15-Pad2_ SW_PUSH
D15 row2 Net-_D15-Pad2_ D
SW16 col3 Net-_D16-Pad2_ SW_PUSH
SW17 col4 Net-_D17-Pad2_ SW_PUSH
SW18 col5 Net-_D18-Pad2_ SW_PUSH
D16 row2 Net-_D16-Pad2_ D
D17 row2 Net-_D17-Pad2_ D
D18 row2 Net-_D18-Pad2_ D
SW13 col0 Net-_D13-Pad2_ SW_PUSH
D13 row2 Net-_D13-Pad2_ D
SW20 col4 Net-_D20-Pad2_ SW_PUSH
D20 row3 Net-_D20-Pad2_ D
SW21 col5 Net-_D21-Pad2_ SW_PUSH
D21 row3 Net-_D21-Pad2_ D
SW19 col3 Net-_D19-Pad2_ SW_PUSH
D19 row3 Net-_D19-Pad2_ D
RSW1 reset GND SW_PUSH
J2 SDA SCL VCC GND OLED
J1 NC_07 data GND VCC MJ-4PP-9
U2 NC_08 data_r GNDA GNDA SDA_r SCL_r row0_r row1_r row2_r row3_r NC_09 NC_10 NC_11 NC_12 col5_r col4_r col3_r col2_r col1_r col0_r VDD reset_r GNDA NC_13 ProMicro
SW23 col1_r Net-_D23-Pad2_ SW_PUSH
D23 row0_r Net-_D23-Pad2_ D
SW24 col2_r Net-_D24-Pad2_ SW_PUSH
D24 row0_r Net-_D24-Pad2_ D
SW25 col3_r Net-_D25-Pad2_ SW_PUSH
SW26 col4_r Net-_D26-Pad2_ SW_PUSH
SW27 col5_r Net-_D27-Pad2_ SW_PUSH
D25 row0_r Net-_D25-Pad2_ D
D26 row0_r Net-_D26-Pad2_ D
D27 row0_r Net-_D27-Pad2_ D
SW22 col0_r Net-_D22-Pad2_ SW_PUSH
D22 row0_r Net-_D22-Pad2_ D
SW29 col1_r Net-_D29-Pad2_ SW_PUSH
D29 row1_r Net-_D29-Pad2_ D
SW30 col2_r Net-_D30-Pad2_ SW_PUSH
D30 row1_r Net-_D30-Pad2_ D
SW31 col3_r Net-_D31-Pad2_ SW_PUSH
SW32 col4_r Net-_D32-Pad2_ SW_PUSH
SW33 col5_r Net-_D33-Pad2_ SW_PUSH
D31 row1_r Net-_D31-Pad2_ D
D32 row1_r Net-_D32-Pad2_ D
D33 row1_r Net-_D33-Pad2_ D
SW28 col0_r Net-_D28-Pad2_ SW_PUSH
D28 row1_r Net-_D28-Pad2_ D
SW35 col1_r Net-_D35-Pad2_ SW_PUSH
D35 row2_r Net-_D35-Pad2_ D
SW36 col2_r Net-_D36-Pad2_ SW_PUSH
D36 row2_r Net-_D36-Pad2_ D
SW37 col3_r Net-_D37-Pad2_ SW_PUSH
SW38 col4_r Net-_D38-Pad2_ SW_PUSH
SW39 col5_r Net-_D39-Pad2_ SW_PUSH
D37 row2_r Net-_D37-Pad2_ D
D38 row2_r Net-_D38-Pad2_ D
D39 row2_r Net-_D39-Pad2_ D
SW34 col0_r Net-_D34-Pad2_ SW_PUSH
D34 row2_r Net-_D34-Pad2_ D
SW41 col4_r Net-_D41-Pad2_ SW_PUSH
D41 row3_r Net-_D41-Pad2_ D
SW42 col5_r Net-_D42-Pad2_ SW_PUSH
D42 row3_r Net-_D42-Pad2_ D
SW40 col3_r Net-_D40-Pad2_ SW_PUSH
D40 row3_r Net-_D40-Pad2_ D
RSW2 reset_r GNDA SW_PUSH
J7 SDA_r SCL_r VDD GNDA OLED
J6 NC_14 data_r GNDA VDD MJ-4PP-9
.end
