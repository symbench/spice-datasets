.title KiCad schematic
P5 /CR_GND Net-_P5-Pad2_ Net-_P5-Pad3_ /CR_VDD CurrentSense
P2 Net-_P2-Pad1_ Net-_P2-Pad2_ PowerAmpMute
P3 Net-_P3-Pad1_ Net-_P3-Pad2_ SPowerAmpMute
P6 GND GND Select-TapeLoop Select-In3 Select-InTape Select-In2 NC_01 Select-In1 VDD VDD InputSelect
P7 GNDD GNDD /Vol_CS /Vol_SCLK /Vol_SDI NC_02 +5VD +5VD VolumeCtrl
C8 +3V3 GND 10u
C9 +3V3 GND 100n
L1 Net-_C2-Pad1_ +3V3 10u
L2 +3V3 Net-_C10-Pad1_ L_Small
C10 Net-_C10-Pad1_ GND 100n
C11 Net-_C10-Pad1_ GND 10u
U1 Net-_C2-Pad1_ GND GND GND GND VoltageSense L78L33ACU
C2 Net-_C2-Pad1_ GND 100n
C1 VoltageSense GND 100u
R8 +3V3 PDI_Clk 10k
P4 PDI_Data +3V3 NC_03 NC_04 PDI_Clk GND PDI
R9 +3V3 SDA 10k
R10 +3V3 SCL 10k
U5 +3V3 SDA SCL GND /CR_GND Net-_P5-Pad2_ Net-_P5-Pad3_ /CR_VDD ISO1541
U4 +3V3 GND VolCtrlSelect MOSI SCK NC_05 NC_06 GND GNDD NC_07 NC_08 /Vol_SCLK /Vol_SDI /Vol_CS GNDD +5VD ISO7241
C13 GNDD +5VD 100n
C12 GND +3V3 100n
R11 /CR_VDD Net-_P5-Pad3_ 10k
R12 /CR_VDD Net-_P5-Pad2_ 10k
U3 Net-_R2-Pad2_ GND Net-_R3-Pad2_ GND Net-_P3-Pad1_ Net-_P3-Pad2_ Net-_P2-Pad1_ Net-_P2-Pad2_ LTV-827
R2 Mute Net-_R2-Pad2_ 420
R3 MuteS Net-_R3-Pad2_ 420
U2 CurrentSense GND VDD VoltageSense +3V3 INA169
R1 VDD VoltageSense 1
R6 CurrentSense GND 1k
C3 CurrentSense GND 100n
D1 GND Net-_D1-Pad2_ LED
D2 GND Net-_D2-Pad2_ LED
R5 +3V3 Net-_D1-Pad2_ 1k
R7 LED Net-_D2-Pad2_ 1k
ROT1 ENC1_Switch ENC1_A GND ENC1_B GND ROTARY-ENCODER
ROT2 ENC2_Switch ENC2_A GND ENC2_B GND ROTARY-ENCODER
C6 +3V3 GND 10u
C7 +3V3 GND 100n
C4 +3V3 GND 10u
C5 +3V3 GND 100n
P1 GND Switch_Power GND Net-_P1-Pad4_ PowerControl
R4 Net-_P1-Pad4_ LED_Power 1k
P8 GND VDD Power
C15 GND +3V3 100n
C14 /CR_VDD /CR_GND 100n
IC2 NC_09 Switch_Power LED_Power NC_10 LED NC_11 OLED-E/RD# OLED-R/W# OLED-D/C# OLED-RES# OLED-CS# NC_12 NC_13 GND +3V3 SDA SCL ENC2_Switch ENC2_A ENC2_B ENC1_Switch ENC1_A ENC1_B GND +3V3 OLED-D0 OLED-D1 OLED-D2 OLED-D3 OLED-D4 OLED-D5 OLED-D6 OLED-D7 GND +3V3 Mute MuteS NC_14 VolCtrlSelect NC_15 MOSI NC_16 SCK GND +3V3 Select-In1 Select-In2 Select-In3 Select-TapeLoop Select-InTape NC_17 GND +3V3 NC_18 NC_19 PDI_Data PDI_Clk NC_20 NC_21 GND Net-_C10-Pad1_ NC_22 VoltageSense CurrentSense ATXMEGA128A3-A
C16 GND +3V3 100n
C19 +3V3 GND 10u
C20 +3V3 GND 100n
C17 +3V3 GND 10u
C18 +3V3 GND 100n
P9 GND VDD Net-_C22-Pad1_ Net-_P9-Pad4_ OLED-D7 OLED-D6 OLED-D5 OLED-D4 OLED-D3 OLED-D2 OLED-D1 OLED-D0 OLED-E/RD# OLED-R/W# OLED-D/C# OLED-RES# OLED-CS# NC_23 +3V3 +3V3 +3V3 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 GND Net-_C24-Pad1_ Display
C21 VDD GND 10u
C22 Net-_C22-Pad1_ GND 10u
R13 Net-_P9-Pad4_ GND 1M
C23 +3V3 GND 1u
C24 Net-_C24-Pad1_ GND 1u
.end
