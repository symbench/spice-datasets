.title KiCad schematic
J1 NC_01 NC_02 Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ NC_03 NC_04 Conn_02x18_Odd_Even
J2 Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ NC_05 NC_06 NC_07 NC_08 Conn_02x25_Odd_Even
U1 Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ Net-_J1-Pad10_ SamtecOmneticsInterconnect
.end
