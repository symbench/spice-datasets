.title KiCad schematic
R215 Net-_Q209-Pad6_ +12V 22R
R220 Net-_C211-Pad1_ Net-_R217-Pad1_ 56k
R230 -12V Net-_Q209-Pad1_ 270k
Q212 /PNP_B /PNP_E Net-_Q212-Pad3_ SS9015
R222 Net-_R217-Pad2_ OutVCF 1k
R227 GND Net-_Q209-Pad5_ 47k
C211 Net-_C211-Pad1_ Net-_C211-Pad2_ 10u
R216 /Coupling Net-_C211-Pad2_ 1k
TP201 Net-_C211-Pad2_ PreOut
R214 /Coupling +12V 180R
Q206 Net-_Q206-Pad1_ Net-_C210-Pad2_ Net-_C209-Pad2_ SS9014
R231 -12V Net-_Q210-Pad1_ 1k2
R232 -12V Net-_Q209-Pad4_ 270k
U201 Net-_R217-Pad2_ Net-_R217-Pad1_ GND -12V GND Net-_R218-Pad2_ Net-_R219-Pad2_ +12V TL072
Q209 Net-_Q209-Pad1_ Net-_Q209-Pad2_ Net-_C211-Pad2_ Net-_Q209-Pad4_ Net-_Q209-Pad5_ Net-_Q209-Pad6_ UMX1N
Q210 Net-_Q210-Pad1_ Net-_Q209-Pad1_ Net-_C211-Pad2_ Net-_Q210-Pad1_ Net-_Q209-Pad4_ Net-_Q209-Pad6_ UMX1N
R226 GND Net-_Q209-Pad2_ 47k
R217 Net-_R217-Pad1_ Net-_R217-Pad2_ 120k
Q201 Net-_C207-Pad2_ Net-_Q201-Pad2_ +12V Net-_C207-Pad1_ Net-_Q201-Pad2_ +12V UMX1N
Q208 Net-_Q208-Pad1_ Net-_C212-Pad1_ Net-_C210-Pad1_ Net-_Q208-Pad1_ Net-_Q208-Pad5_ Net-_C210-Pad2_ UMX1N
Q207 Net-_Q206-Pad1_ Net-_C210-Pad1_ Net-_C209-Pad1_ SS9014
C209 Net-_C209-Pad1_ Net-_C209-Pad2_ 47n
Q204 Net-_Q204-Pad1_ Net-_C209-Pad2_ Net-_C208-Pad2_ SS9014
Q205 Net-_Q204-Pad1_ Net-_C209-Pad1_ Net-_C208-Pad1_ SS9014
C208 Net-_C208-Pad1_ Net-_C208-Pad2_ 47n
Q202 Net-_Q202-Pad1_ Net-_C208-Pad2_ Net-_C207-Pad2_ SS9014
Q203 Net-_Q202-Pad1_ Net-_C208-Pad1_ Net-_C207-Pad1_ SS9014
C207 Net-_C207-Pad1_ Net-_C207-Pad2_ 47n
C210 Net-_C210-Pad1_ Net-_C210-Pad2_ 47n
R201 Net-_Q201-Pad2_ +12V 330R
R206 Net-_Q202-Pad1_ Net-_Q201-Pad2_ 150R
R210 Net-_Q204-Pad1_ Net-_Q202-Pad1_ 150R
R213 Net-_Q206-Pad1_ Net-_Q204-Pad1_ 150R
Q211 /PNP_E GND Net-_Q211-Pad3_ SS9014
R228 Net-_Q211-Pad3_ Net-_Q208-Pad1_ 1k
R225 Net-_C213-Pad1_ Net-_C212-Pad1_ 470R
R224 Net-_C213-Pad1_ Net-_Q206-Pad1_ 150R
R229 Net-_C213-Pad1_ Net-_R229-Pad2_ 330R
R233 GND Net-_C213-Pad1_ 220R
RV202 Net-_R211-Pad1_ Net-_Q208-Pad5_ Net-_R229-Pad2_ 1k
RV201 Net-_R211-Pad1_ Net-_R211-Pad2_ /Coupling 50k_emphasis
R211 Net-_R211-Pad1_ Net-_R211-Pad2_ 0R
R212 /Coupling Net-_R211-Pad2_ Open
TP202 Net-_C212-Pad1_ Input
R239 GND Net-_Q212-Pad3_ 470R
C214 GND Net-_C213-Pad1_ 22u
C213 Net-_C213-Pad1_ GND Opt_220u
C215 GND /PNP_B 100p
RV205 Net-_R237-Pad1_ GND GND 500R
R237 Net-_R237-Pad1_ /PNP_B 1k8
R219 Net-_R218-Pad2_ Net-_R219-Pad2_ 56k
R223 Net-_R219-Pad2_ Net-_C212-Pad2_ 10k
R218 InAudio1 Net-_R218-Pad2_ 120k
C212 Net-_C212-Pad1_ Net-_C212-Pad2_ 10u
R221 InAudio2 Net-_R218-Pad2_ 120k
RV203 CV1 Net-_R238-Pad1_ GND 50k_CV1
R234 Net-_R234-Pad1_ /PNP_B 100k
R238 Net-_R238-Pad1_ /PNP_B 100k
RV204 Net-_R235-Pad1_ Net-_R236-Pad2_ GND 10k_Freq
R236 /PNP_B Net-_R236-Pad2_ 150k
R235 Net-_R235-Pad1_ +12V 680R
RV206 CV2 Net-_R234-Pad1_ GND 50k_CV2
D204 GND Net-_D203-Pad2_ Zener
D203 CV2 Net-_D203-Pad2_ Zener
J201 GND Net-_J201-PadT_ GND CV2
R204 CV2 GND OPEN
R202 Net-_J201-PadT_ CV2 1K
D208 GND Net-_D207-Pad2_ Zener
D207 CV1 Net-_D207-Pad2_ Zener
D205 InAudio2 Net-_D205-Pad2_ Zener
D206 GND Net-_D205-Pad2_ Zener
C204 -12V GND 10u
C201 GND +12V 10u
R208 Net-_J204-PadT_ OutVCF 0R
J202 GND Net-_J202-PadT_ GND Input2
J204 GND Net-_J204-PadT_ Out VCF
J203 GND Net-_J203-PadT_ GND CV1
R209 CV1 GND OPEN
R207 Net-_J203-PadT_ CV1 1K
R205 InAudio2 GND OPEN
R203 Net-_J202-PadT_ InAudio2 1K
P201 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
H203 2,2mm
H204 2,2mm
H202 2,5mm
H201 2,5mm
D202 GND -12V 1N1007
D201 +12V GND 1N1007
C203 GND +12V 100n
C206 -12V GND 100n
C205 -12V GND 100n
C202 GND +12V 100n
J205 GND Net-_J205-PadT_ GND Input1
R241 InAudio1 GND OPEN
R240 Net-_J205-PadT_ InAudio1 1K
D209 InAudio1 Net-_D209-Pad2_ Zener
D210 GND Net-_D209-Pad2_ Zener
R242 -12V Net-_D211-Pad1_ 12K
D211 Net-_D211-Pad1_ GND LED
RV207 +12V Net-_R243-Pad2_ GND 10k
R243 /PNP_E Net-_R243-Pad2_ 100k
.end
