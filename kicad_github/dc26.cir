.title KiCad schematic
B_SHIFT_2 Net-_BLD1-Pad1_ Net-_BCLK1-Pad1_ NC_01 NC_02 NC_03 NC_04 NC_05 GND Net-_BDATA1-Pad1_ Net-_B_SHIFT_1-Pad9_ Net-_B_SHIFT_2-Pad11_ Net-_B_SELECT1-Pad2_ NC_06 NC_07 GND +3V3 74LS165
B_L1 +3V3 Net-_B_L1-Pad2_ SW_Push
B_L2 +3V3 Net-_B_L2-Pad2_ SW_Push
B_L3 +3V3 Net-_B_L3-Pad2_ SW_Push
B_L4 +3V3 Net-_B_L4-Pad2_ SW_Push
B_R1 +3V3 Net-_B_R1-Pad2_ SW_Push
B_R2 +3V3 Net-_B_R2-Pad2_ SW_Push
B_R3 +3V3 Net-_B_R3-Pad2_ SW_Push
B_R4 +3V3 Net-_B_R4-Pad2_ SW_Push
B_START1 +3V3 Net-_B_SHIFT_2-Pad11_ SW_Push
B_SELECT1 +3V3 Net-_B_SELECT1-Pad2_ SW_Push
R4 GND Net-_B_L1-Pad2_ 10k
R5 GND Net-_B_L2-Pad2_ 10k
R6 GND Net-_B_L3-Pad2_ 10k
R7 GND Net-_B_L4-Pad2_ 10k
R8 GND Net-_B_R1-Pad2_ 10k
R9 GND Net-_B_R2-Pad2_ 10k
R10 GND Net-_B_R3-Pad2_ 10k
R11 GND Net-_B_R4-Pad2_ 10k
R12 GND Net-_B_SHIFT_2-Pad11_ 10k
R13 GND Net-_B_SELECT1-Pad2_ 10k
STM32F405 NC_08 NC_09 NC_10 NC_11 Net-_C24-Pad2_ Net-_C25-Pad1_ Net-_NRST1-Pad1_ Net-_PC0-Pad1_ Net-_PC1-Pad1_ Net-_PC2-Pad1_ Net-_PC3-Pad1_ GND +3V3 NC_12 BATT-BUCK-ENABLE MPU6000-INT Net-_BCLK1-Pad1_ GND +3V3 MPU6000-CS MPU6000-SCLK MPU6000-MISO MPU6000-MOSI Net-_PC4-Pad1_ Net-_PC5-Pad1_ Net-_BDATA1-Pad1_ Net-_C2-Pad1_ GND IR-TX-R IR-RX-R Net-_C26-Pad1_ +3V3 NC_13 LED-CKI NC_14 LED-SDI Net-_PC6-Pad1_ Net-_PC7-Pad1_ Net-_PC8-Pad1_ NC_15 NC_16 USB-VBUS USB-ID USB-DM USB-DP Net-_STM32F405-Pad46_ Net-_C27-Pad1_ +3V3 Net-_STM32F405-Pad49_ LED-POWER-ENABLE IR-TX-F IR-RX-F NC_17 NC_18 NC_19 NC_20 Net-_BLD1-Pad1_ IR-TX-L IR-RX-L Net-_BT0-Pad1_ NC_21 NC_22 GND +3V3 STM32F405RGTx
C25 Net-_C25-Pad1_ GND 22pF
C24 GND Net-_C24-Pad2_ 22pF
C27 Net-_C27-Pad1_ GND 2u2
C26 Net-_C26-Pad1_ GND 2u2
C31 GND +3V3 0.1pF
C30 GND +3V3 0.1pF
C28 +3V3 GND 0.1pF
C29 +3V3 GND 0.1pF
R15 +3V3 Net-_NRST1-Pad1_ 10k
SW_RESET1 GND Net-_NRST1-Pad1_ SW_SPST
R14 Net-_BT0-Pad1_ GND 10k
SW_BOOT0 +3V3 Net-_BT0-Pad1_ SW_SPST
SWDCLK1 Net-_STM32F405-Pad49_ PGM-SWDCLK
SWDIO1 Net-_STM32F405-Pad46_ PGM-SWDIO
PGND1 GND PGM-GND
NRST1 Net-_NRST1-Pad1_ NRST
BT0 Net-_BT0-Pad1_ BOOT0
C32 GND +3V3 0.1pF
BLD1 Net-_BLD1-Pad1_ BTN-LD
BCLK1 Net-_BCLK1-Pad1_ BTN-CLK
BDATA1 Net-_BDATA1-Pad1_ BTN-DATA
BGND2 GND BTN-GND
Y1 Net-_C24-Pad2_ Net-_C25-Pad1_ Crystal
B_SHIFT_1 Net-_BLD1-Pad1_ Net-_BCLK1-Pad1_ Net-_B_R1-Pad2_ Net-_B_R2-Pad2_ Net-_B_R3-Pad2_ Net-_B_R4-Pad2_ NC_23 GND Net-_B_SHIFT_1-Pad9_ NC_24 Net-_B_L1-Pad2_ Net-_B_L2-Pad2_ Net-_B_L3-Pad2_ Net-_B_L4-Pad2_ GND +3V3 74LS165
PC0 Net-_PC0-Pad1_ PC0
PC1 Net-_PC1-Pad1_ PC1
PC2 Net-_PC2-Pad1_ PC2
PC3 Net-_PC3-Pad1_ PC3
PC4 Net-_PC4-Pad1_ PC4
PC5 Net-_PC5-Pad1_ PC5
PC6 Net-_PC6-Pad1_ PC6
PC7 Net-_PC7-Pad1_ PC7
PC8 Net-_PC8-Pad1_ PC8
IRTXF1 IR-TX-F IRTXF
IRRXF1 IR-RX-F IRRXF
VBAT-DIV1 GND Net-_C2-Pad1_ +BATT 5k-10k
C2 Net-_C2-Pad1_ GND 0.1uF
BATT-BUCK1 +BATT Net-_BATT-BUCK-INDUC1-Pad2_ GND +5V BATT-BUCK-ENABLE LM2596S-5
SW_PWRON1 GND BATT-BUCK-ENABLE SW_SPST
BATT-BUCK-INDUC1 +5V Net-_BATT-BUCK-INDUC1-Pad2_ 44uH
BATT-BUCK-COUT1 +5V GND 220uF
BATT-BUCK-CIN1 +BATT GND 100uF
BATT-BUCK-PULLUP1 +BATT BATT-BUCK-ENABLE 10k
JBBEN1 BATT-BUCK-ENABLE GND BUCK-EN
BBEN1 BATT-BUCK-ENABLE BUCK-EN
BIN1 +BATT BT-IN
BGND1 GND BT-GND
REG_3V3 +5V GND +3V3 GND TC1262-33VDB
R17 +3V3 Net-_PWR_3V3-Pad1_ 470R
PWR_3V3 Net-_PWR_3V3-Pad1_ GND LED
C33 +5V GND 4u7
C34 +3V3 GND 4u7
BATT-BUCK-SCHOTT1 GND Net-_BATT-BUCK-INDUC1-Pad2_ D_Schottky
R20 +5V Net-_PWR_5V1-Pad1_ 470R
PWR_5V1 Net-_PWR_5V1-Pad1_ GND LED
MPU6000 GND NC_25 NC_26 MPU6000-CS MPU6000-MISO Net-_C37-Pad2_ NC_27 MPU6000-INT +3V3 GND Net-_C38-Pad1_ MPU6000-SCLK MPU6000-MOSI MPU-6000
C37 GND Net-_C37-Pad2_ 0.1uF
C38 Net-_C38-Pad1_ GND 10nF
C36 +3V3 GND 10nF
MCS1 MPU6000-CS M-CS
MSCLK1 MPU6000-SCLK M-SCLK
MMISO1 MPU6000-MISO M-MISO
MMOSI1 MPU6000-MOSI M-MOSI
MINT1 MPU6000-INT M-INT1
F405_USB1 USB-VBUS Net-_F405_USB1-Pad2_ Net-_F405_USB1-Pad3_ Net-_F405_USB1-Pad4_ GND NC_28 USB_OTG
R18 USB-DP Net-_F405_USB1-Pad3_ 22
R19 USB-DM Net-_F405_USB1-Pad2_ 22
C35 USB-VBUS GND 4U7
UID1 Net-_F405_USB1-Pad4_ USB-ID
JUID1 USB-ID Net-_F405_USB1-Pad4_ USB-ID
JUVCC1 +5V USB-VBUS USB-VCC
D1 Net-_D1-Pad1_ LED-SDI LED-CKI GND VCC Net-_D1-Pad6_ APA102
D25 Net-_D25-Pad1_ Net-_D1-Pad1_ Net-_D1-Pad6_ GND VCC Net-_D25-Pad6_ APA102
D49 Net-_D49-Pad1_ Net-_D25-Pad1_ Net-_D25-Pad6_ GND VCC Net-_D49-Pad6_ APA102
D73 Net-_D73-Pad1_ Net-_D49-Pad1_ Net-_D49-Pad6_ GND VCC Net-_D73-Pad6_ APA102
D97 Net-_D121-Pad2_ Net-_D73-Pad1_ Net-_D73-Pad6_ GND VCC Net-_D121-Pad3_ APA102
D121 Net-_D121-Pad1_ Net-_D121-Pad2_ Net-_D121-Pad3_ GND VCC Net-_D121-Pad6_ APA102
D145 Net-_D145-Pad1_ Net-_D121-Pad1_ Net-_D121-Pad6_ GND VCC Net-_D145-Pad6_ APA102
D169 Net-_D169-Pad1_ Net-_D145-Pad1_ Net-_D145-Pad6_ GND VCC Net-_D169-Pad6_ APA102
D193 Net-_D193-Pad1_ Net-_D169-Pad1_ Net-_D169-Pad6_ GND VCC Net-_D193-Pad6_ APA102
D217 Net-_D217-Pad1_ Net-_D193-Pad1_ Net-_D193-Pad6_ GND VCC Net-_D217-Pad6_ APA102
D241 Net-_D241-Pad1_ Net-_D217-Pad1_ Net-_D217-Pad6_ GND VCC Net-_D241-Pad6_ APA102
D265 Net-_D265-Pad1_ Net-_D241-Pad1_ Net-_D241-Pad6_ GND VCC Net-_D265-Pad6_ APA102
D289 Net-_D289-Pad1_ Net-_D265-Pad1_ Net-_D265-Pad6_ GND VCC Net-_D289-Pad6_ APA102
D313 Net-_D313-Pad1_ Net-_D289-Pad1_ Net-_D289-Pad6_ GND VCC Net-_D313-Pad6_ APA102
D337 Net-_D337-Pad1_ Net-_D313-Pad1_ Net-_D313-Pad6_ GND VCC Net-_D337-Pad6_ APA102
D361 Net-_D361-Pad1_ Net-_D337-Pad1_ Net-_D337-Pad6_ GND VCC Net-_D361-Pad6_ APA102
D385 Net-_D385-Pad1_ Net-_D361-Pad1_ Net-_D361-Pad6_ GND VCC Net-_D385-Pad6_ APA102
D409 Net-_D409-Pad1_ Net-_D385-Pad1_ Net-_D385-Pad6_ GND VCC Net-_D409-Pad6_ APA102
D433 Net-_D433-Pad1_ Net-_D409-Pad1_ Net-_D409-Pad6_ GND VCC Net-_D433-Pad6_ APA102
D457 Net-_D457-Pad1_ Net-_D433-Pad1_ Net-_D433-Pad6_ GND VCC Net-_D457-Pad6_ APA102
D481 Net-_D481-Pad1_ Net-_D457-Pad1_ Net-_D457-Pad6_ GND VCC Net-_D481-Pad6_ APA102
D505 Net-_D505-Pad1_ Net-_D481-Pad1_ Net-_D481-Pad6_ GND VCC Net-_D505-Pad6_ APA102
D529 Net-_D529-Pad1_ Net-_D505-Pad1_ Net-_D505-Pad6_ GND VCC Net-_D529-Pad6_ APA102
D553 Net-_D2-Pad2_ Net-_D529-Pad1_ Net-_D529-Pad6_ GND VCC Net-_D2-Pad3_ APA102
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ Net-_D2-Pad3_ GND VCC Net-_D2-Pad6_ APA102
D26 Net-_D26-Pad1_ Net-_D2-Pad1_ Net-_D2-Pad6_ GND VCC Net-_D26-Pad6_ APA102
D50 Net-_D50-Pad1_ Net-_D26-Pad1_ Net-_D26-Pad6_ GND VCC Net-_D50-Pad6_ APA102
D74 Net-_D74-Pad1_ Net-_D50-Pad1_ Net-_D50-Pad6_ GND VCC Net-_D74-Pad6_ APA102
D98 Net-_D122-Pad2_ Net-_D74-Pad1_ Net-_D74-Pad6_ GND VCC Net-_D122-Pad3_ APA102
D122 Net-_D122-Pad1_ Net-_D122-Pad2_ Net-_D122-Pad3_ GND VCC Net-_D122-Pad6_ APA102
D146 Net-_D146-Pad1_ Net-_D122-Pad1_ Net-_D122-Pad6_ GND VCC Net-_D146-Pad6_ APA102
D170 Net-_D170-Pad1_ Net-_D146-Pad1_ Net-_D146-Pad6_ GND VCC Net-_D170-Pad6_ APA102
D194 Net-_D194-Pad1_ Net-_D170-Pad1_ Net-_D170-Pad6_ GND VCC Net-_D194-Pad6_ APA102
D218 Net-_D218-Pad1_ Net-_D194-Pad1_ Net-_D194-Pad6_ GND VCC Net-_D218-Pad6_ APA102
D242 Net-_D242-Pad1_ Net-_D218-Pad1_ Net-_D218-Pad6_ GND VCC Net-_D242-Pad6_ APA102
D266 Net-_D266-Pad1_ Net-_D242-Pad1_ Net-_D242-Pad6_ GND VCC Net-_D266-Pad6_ APA102
D290 Net-_D290-Pad1_ Net-_D266-Pad1_ Net-_D266-Pad6_ GND VCC Net-_D290-Pad6_ APA102
D314 Net-_D314-Pad1_ Net-_D290-Pad1_ Net-_D290-Pad6_ GND VCC Net-_D314-Pad6_ APA102
D338 Net-_D338-Pad1_ Net-_D314-Pad1_ Net-_D314-Pad6_ GND VCC Net-_D338-Pad6_ APA102
D362 Net-_D362-Pad1_ Net-_D338-Pad1_ Net-_D338-Pad6_ GND VCC Net-_D362-Pad6_ APA102
D386 Net-_D386-Pad1_ Net-_D362-Pad1_ Net-_D362-Pad6_ GND VCC Net-_D386-Pad6_ APA102
D410 Net-_D410-Pad1_ Net-_D386-Pad1_ Net-_D386-Pad6_ GND VCC Net-_D410-Pad6_ APA102
D434 Net-_D434-Pad1_ Net-_D410-Pad1_ Net-_D410-Pad6_ GND VCC Net-_D434-Pad6_ APA102
D458 Net-_D458-Pad1_ Net-_D434-Pad1_ Net-_D434-Pad6_ GND VCC Net-_D458-Pad6_ APA102
D482 Net-_D482-Pad1_ Net-_D458-Pad1_ Net-_D458-Pad6_ GND VCC Net-_D482-Pad6_ APA102
D506 Net-_D506-Pad1_ Net-_D482-Pad1_ Net-_D482-Pad6_ GND VCC Net-_D506-Pad6_ APA102
D530 Net-_D530-Pad1_ Net-_D506-Pad1_ Net-_D506-Pad6_ GND VCC Net-_D530-Pad6_ APA102
D554 Net-_D3-Pad2_ Net-_D530-Pad1_ Net-_D530-Pad6_ GND VCC Net-_D3-Pad3_ APA102
D3 Net-_D27-Pad2_ Net-_D3-Pad2_ Net-_D3-Pad3_ GND VCC Net-_D27-Pad3_ APA102
D27 Net-_D27-Pad1_ Net-_D27-Pad2_ Net-_D27-Pad3_ GND VCC Net-_D27-Pad6_ APA102
D51 Net-_D51-Pad1_ Net-_D27-Pad1_ Net-_D27-Pad6_ GND VCC Net-_D51-Pad6_ APA102
D75 Net-_D75-Pad1_ Net-_D51-Pad1_ Net-_D51-Pad6_ GND VCC Net-_D75-Pad6_ APA102
D99 Net-_D123-Pad2_ Net-_D75-Pad1_ Net-_D75-Pad6_ GND VCC Net-_D123-Pad3_ APA102
D123 Net-_D123-Pad1_ Net-_D123-Pad2_ Net-_D123-Pad3_ GND VCC Net-_D123-Pad6_ APA102
D147 Net-_D147-Pad1_ Net-_D123-Pad1_ Net-_D123-Pad6_ GND VCC Net-_D147-Pad6_ APA102
D171 Net-_D171-Pad1_ Net-_D147-Pad1_ Net-_D147-Pad6_ GND VCC Net-_D171-Pad6_ APA102
D195 Net-_D195-Pad1_ Net-_D171-Pad1_ Net-_D171-Pad6_ GND VCC Net-_D195-Pad6_ APA102
D219 Net-_D219-Pad1_ Net-_D195-Pad1_ Net-_D195-Pad6_ GND VCC Net-_D219-Pad6_ APA102
D243 Net-_D243-Pad1_ Net-_D219-Pad1_ Net-_D219-Pad6_ GND VCC Net-_D243-Pad6_ APA102
D267 Net-_D267-Pad1_ Net-_D243-Pad1_ Net-_D243-Pad6_ GND VCC Net-_D267-Pad6_ APA102
D291 Net-_D291-Pad1_ Net-_D267-Pad1_ Net-_D267-Pad6_ GND VCC Net-_D291-Pad6_ APA102
D315 Net-_D315-Pad1_ Net-_D291-Pad1_ Net-_D291-Pad6_ GND VCC Net-_D315-Pad6_ APA102
D339 Net-_D339-Pad1_ Net-_D315-Pad1_ Net-_D315-Pad6_ GND VCC Net-_D339-Pad6_ APA102
D363 Net-_D363-Pad1_ Net-_D339-Pad1_ Net-_D339-Pad6_ GND VCC Net-_D363-Pad6_ APA102
D387 Net-_D387-Pad1_ Net-_D363-Pad1_ Net-_D363-Pad6_ GND VCC Net-_D387-Pad6_ APA102
D411 Net-_D411-Pad1_ Net-_D387-Pad1_ Net-_D387-Pad6_ GND VCC Net-_D411-Pad6_ APA102
D435 Net-_D435-Pad1_ Net-_D411-Pad1_ Net-_D411-Pad6_ GND VCC Net-_D435-Pad6_ APA102
D459 Net-_D459-Pad1_ Net-_D435-Pad1_ Net-_D435-Pad6_ GND VCC Net-_D459-Pad6_ APA102
D483 Net-_D483-Pad1_ Net-_D459-Pad1_ Net-_D459-Pad6_ GND VCC Net-_D483-Pad6_ APA102
D507 Net-_D507-Pad1_ Net-_D483-Pad1_ Net-_D483-Pad6_ GND VCC Net-_D507-Pad6_ APA102
D531 Net-_D531-Pad1_ Net-_D507-Pad1_ Net-_D507-Pad6_ GND VCC Net-_D531-Pad6_ APA102
D555 Net-_D4-Pad2_ Net-_D531-Pad1_ Net-_D531-Pad6_ GND VCC Net-_D4-Pad3_ APA102
D4 Net-_D28-Pad2_ Net-_D4-Pad2_ Net-_D4-Pad3_ GND VCC Net-_D28-Pad3_ APA102
D28 Net-_D28-Pad1_ Net-_D28-Pad2_ Net-_D28-Pad3_ GND VCC Net-_D28-Pad6_ APA102
D52 Net-_D52-Pad1_ Net-_D28-Pad1_ Net-_D28-Pad6_ GND VCC Net-_D52-Pad6_ APA102
D76 Net-_D100-Pad2_ Net-_D52-Pad1_ Net-_D52-Pad6_ GND VCC Net-_D100-Pad3_ APA102
D100 Net-_D100-Pad1_ Net-_D100-Pad2_ Net-_D100-Pad3_ GND VCC Net-_D100-Pad6_ APA102
D124 Net-_D124-Pad1_ Net-_D100-Pad1_ Net-_D100-Pad6_ GND VCC Net-_D124-Pad6_ APA102
D148 Net-_D148-Pad1_ Net-_D124-Pad1_ Net-_D124-Pad6_ GND VCC Net-_D148-Pad6_ APA102
D172 Net-_D172-Pad1_ Net-_D148-Pad1_ Net-_D148-Pad6_ GND VCC Net-_D172-Pad6_ APA102
D196 Net-_D196-Pad1_ Net-_D172-Pad1_ Net-_D172-Pad6_ GND VCC Net-_D196-Pad6_ APA102
D220 Net-_D220-Pad1_ Net-_D196-Pad1_ Net-_D196-Pad6_ GND VCC Net-_D220-Pad6_ APA102
D244 Net-_D244-Pad1_ Net-_D220-Pad1_ Net-_D220-Pad6_ GND VCC Net-_D244-Pad6_ APA102
D268 Net-_D268-Pad1_ Net-_D244-Pad1_ Net-_D244-Pad6_ GND VCC Net-_D268-Pad6_ APA102
D292 Net-_D292-Pad1_ Net-_D268-Pad1_ Net-_D268-Pad6_ GND VCC Net-_D292-Pad6_ APA102
D316 Net-_D316-Pad1_ Net-_D292-Pad1_ Net-_D292-Pad6_ GND VCC Net-_D316-Pad6_ APA102
D340 Net-_D340-Pad1_ Net-_D316-Pad1_ Net-_D316-Pad6_ GND VCC Net-_D340-Pad6_ APA102
D364 Net-_D364-Pad1_ Net-_D340-Pad1_ Net-_D340-Pad6_ GND VCC Net-_D364-Pad6_ APA102
D388 Net-_D388-Pad1_ Net-_D364-Pad1_ Net-_D364-Pad6_ GND VCC Net-_D388-Pad6_ APA102
D412 Net-_D412-Pad1_ Net-_D388-Pad1_ Net-_D388-Pad6_ GND VCC Net-_D412-Pad6_ APA102
D436 Net-_D436-Pad1_ Net-_D412-Pad1_ Net-_D412-Pad6_ GND VCC Net-_D436-Pad6_ APA102
D460 Net-_D460-Pad1_ Net-_D436-Pad1_ Net-_D436-Pad6_ GND VCC Net-_D460-Pad6_ APA102
D484 Net-_D484-Pad1_ Net-_D460-Pad1_ Net-_D460-Pad6_ GND VCC Net-_D484-Pad6_ APA102
D508 Net-_D508-Pad1_ Net-_D484-Pad1_ Net-_D484-Pad6_ GND VCC Net-_D508-Pad6_ APA102
D532 Net-_D532-Pad1_ Net-_D508-Pad1_ Net-_D508-Pad6_ GND VCC Net-_D532-Pad6_ APA102
D556 Net-_D5-Pad2_ Net-_D532-Pad1_ Net-_D532-Pad6_ GND VCC Net-_D5-Pad3_ APA102
D5 Net-_D29-Pad2_ Net-_D5-Pad2_ Net-_D5-Pad3_ GND VCC Net-_D29-Pad3_ APA102
D29 Net-_D29-Pad1_ Net-_D29-Pad2_ Net-_D29-Pad3_ GND VCC Net-_D29-Pad6_ APA102
D53 Net-_D53-Pad1_ Net-_D29-Pad1_ Net-_D29-Pad6_ GND VCC Net-_D53-Pad6_ APA102
D77 Net-_D101-Pad2_ Net-_D53-Pad1_ Net-_D53-Pad6_ GND VCC Net-_D101-Pad3_ APA102
D101 Net-_D101-Pad1_ Net-_D101-Pad2_ Net-_D101-Pad3_ GND VCC Net-_D101-Pad6_ APA102
D125 Net-_D125-Pad1_ Net-_D101-Pad1_ Net-_D101-Pad6_ GND VCC Net-_D125-Pad6_ APA102
D149 Net-_D149-Pad1_ Net-_D125-Pad1_ Net-_D125-Pad6_ GND VCC Net-_D149-Pad6_ APA102
D173 Net-_D173-Pad1_ Net-_D149-Pad1_ Net-_D149-Pad6_ GND VCC Net-_D173-Pad6_ APA102
D197 Net-_D197-Pad1_ Net-_D173-Pad1_ Net-_D173-Pad6_ GND VCC Net-_D197-Pad6_ APA102
D221 Net-_D221-Pad1_ Net-_D197-Pad1_ Net-_D197-Pad6_ GND VCC Net-_D221-Pad6_ APA102
D245 Net-_D245-Pad1_ Net-_D221-Pad1_ Net-_D221-Pad6_ GND VCC Net-_D245-Pad6_ APA102
D269 Net-_D269-Pad1_ Net-_D245-Pad1_ Net-_D245-Pad6_ GND VCC Net-_D269-Pad6_ APA102
D293 Net-_D293-Pad1_ Net-_D269-Pad1_ Net-_D269-Pad6_ GND VCC Net-_D293-Pad6_ APA102
D317 Net-_D317-Pad1_ Net-_D293-Pad1_ Net-_D293-Pad6_ GND VCC Net-_D317-Pad6_ APA102
D341 Net-_D341-Pad1_ Net-_D317-Pad1_ Net-_D317-Pad6_ GND VCC Net-_D341-Pad6_ APA102
D365 Net-_D365-Pad1_ Net-_D341-Pad1_ Net-_D341-Pad6_ GND VCC Net-_D365-Pad6_ APA102
D389 Net-_D389-Pad1_ Net-_D365-Pad1_ Net-_D365-Pad6_ GND VCC Net-_D389-Pad6_ APA102
D413 Net-_D413-Pad1_ Net-_D389-Pad1_ Net-_D389-Pad6_ GND VCC Net-_D413-Pad6_ APA102
D437 Net-_D437-Pad1_ Net-_D413-Pad1_ Net-_D413-Pad6_ GND VCC Net-_D437-Pad6_ APA102
D461 Net-_D461-Pad1_ Net-_D437-Pad1_ Net-_D437-Pad6_ GND VCC Net-_D461-Pad6_ APA102
D485 Net-_D485-Pad1_ Net-_D461-Pad1_ Net-_D461-Pad6_ GND VCC Net-_D485-Pad6_ APA102
D509 Net-_D509-Pad1_ Net-_D485-Pad1_ Net-_D485-Pad6_ GND VCC Net-_D509-Pad6_ APA102
D533 Net-_D533-Pad1_ Net-_D509-Pad1_ Net-_D509-Pad6_ GND VCC Net-_D533-Pad6_ APA102
D557 Net-_D557-Pad1_ Net-_D533-Pad1_ Net-_D533-Pad6_ GND VCC Net-_D557-Pad6_ APA102
D6 Net-_D30-Pad2_ Net-_D557-Pad1_ Net-_D557-Pad6_ GND VCC Net-_D30-Pad3_ APA102
D30 Net-_D30-Pad1_ Net-_D30-Pad2_ Net-_D30-Pad3_ GND VCC Net-_D30-Pad6_ APA102
D54 Net-_D54-Pad1_ Net-_D30-Pad1_ Net-_D30-Pad6_ GND VCC Net-_D54-Pad6_ APA102
D78 Net-_D102-Pad2_ Net-_D54-Pad1_ Net-_D54-Pad6_ GND VCC Net-_D102-Pad3_ APA102
D102 Net-_D102-Pad1_ Net-_D102-Pad2_ Net-_D102-Pad3_ GND VCC Net-_D102-Pad6_ APA102
D126 Net-_D126-Pad1_ Net-_D102-Pad1_ Net-_D102-Pad6_ GND VCC Net-_D126-Pad6_ APA102
D150 Net-_D150-Pad1_ Net-_D126-Pad1_ Net-_D126-Pad6_ GND VCC Net-_D150-Pad6_ APA102
D174 Net-_D174-Pad1_ Net-_D150-Pad1_ Net-_D150-Pad6_ GND VCC Net-_D174-Pad6_ APA102
D198 Net-_D198-Pad1_ Net-_D174-Pad1_ Net-_D174-Pad6_ GND VCC Net-_D198-Pad6_ APA102
D222 Net-_D222-Pad1_ Net-_D198-Pad1_ Net-_D198-Pad6_ GND VCC Net-_D222-Pad6_ APA102
D246 Net-_D246-Pad1_ Net-_D222-Pad1_ Net-_D222-Pad6_ GND VCC Net-_D246-Pad6_ APA102
D270 Net-_D270-Pad1_ Net-_D246-Pad1_ Net-_D246-Pad6_ GND VCC Net-_D270-Pad6_ APA102
D294 Net-_D294-Pad1_ Net-_D270-Pad1_ Net-_D270-Pad6_ GND VCC Net-_D294-Pad6_ APA102
D318 Net-_D318-Pad1_ Net-_D294-Pad1_ Net-_D294-Pad6_ GND VCC Net-_D318-Pad6_ APA102
D342 Net-_D342-Pad1_ Net-_D318-Pad1_ Net-_D318-Pad6_ GND VCC Net-_D342-Pad6_ APA102
D366 Net-_D366-Pad1_ Net-_D342-Pad1_ Net-_D342-Pad6_ GND VCC Net-_D366-Pad6_ APA102
D390 Net-_D390-Pad1_ Net-_D366-Pad1_ Net-_D366-Pad6_ GND VCC Net-_D390-Pad6_ APA102
D414 Net-_D414-Pad1_ Net-_D390-Pad1_ Net-_D390-Pad6_ GND VCC Net-_D414-Pad6_ APA102
D438 Net-_D438-Pad1_ Net-_D414-Pad1_ Net-_D414-Pad6_ GND VCC Net-_D438-Pad6_ APA102
D462 Net-_D462-Pad1_ Net-_D438-Pad1_ Net-_D438-Pad6_ GND VCC Net-_D462-Pad6_ APA102
D486 Net-_D486-Pad1_ Net-_D462-Pad1_ Net-_D462-Pad6_ GND VCC Net-_D486-Pad6_ APA102
D510 Net-_D510-Pad1_ Net-_D486-Pad1_ Net-_D486-Pad6_ GND VCC Net-_D510-Pad6_ APA102
D534 Net-_D534-Pad1_ Net-_D510-Pad1_ Net-_D510-Pad6_ GND VCC Net-_D534-Pad6_ APA102
D558 Net-_D558-Pad1_ Net-_D534-Pad1_ Net-_D534-Pad6_ GND VCC Net-_D558-Pad6_ APA102
D7 Net-_D31-Pad2_ Net-_D558-Pad1_ Net-_D558-Pad6_ GND VCC Net-_D31-Pad3_ APA102
D31 Net-_D31-Pad1_ Net-_D31-Pad2_ Net-_D31-Pad3_ GND VCC Net-_D31-Pad6_ APA102
D55 Net-_D55-Pad1_ Net-_D31-Pad1_ Net-_D31-Pad6_ GND VCC Net-_D55-Pad6_ APA102
D79 Net-_D103-Pad2_ Net-_D55-Pad1_ Net-_D55-Pad6_ GND VCC Net-_D103-Pad3_ APA102
D103 Net-_D103-Pad1_ Net-_D103-Pad2_ Net-_D103-Pad3_ GND VCC Net-_D103-Pad6_ APA102
D127 Net-_D127-Pad1_ Net-_D103-Pad1_ Net-_D103-Pad6_ GND VCC Net-_D127-Pad6_ APA102
D151 Net-_D151-Pad1_ Net-_D127-Pad1_ Net-_D127-Pad6_ GND VCC Net-_D151-Pad6_ APA102
D175 Net-_D175-Pad1_ Net-_D151-Pad1_ Net-_D151-Pad6_ GND VCC Net-_D175-Pad6_ APA102
D199 Net-_D199-Pad1_ Net-_D175-Pad1_ Net-_D175-Pad6_ GND VCC Net-_D199-Pad6_ APA102
D223 Net-_D223-Pad1_ Net-_D199-Pad1_ Net-_D199-Pad6_ GND VCC Net-_D223-Pad6_ APA102
D247 Net-_D247-Pad1_ Net-_D223-Pad1_ Net-_D223-Pad6_ GND VCC Net-_D247-Pad6_ APA102
D271 Net-_D271-Pad1_ Net-_D247-Pad1_ Net-_D247-Pad6_ GND VCC Net-_D271-Pad6_ APA102
D295 Net-_D295-Pad1_ Net-_D271-Pad1_ Net-_D271-Pad6_ GND VCC Net-_D295-Pad6_ APA102
D319 Net-_D319-Pad1_ Net-_D295-Pad1_ Net-_D295-Pad6_ GND VCC Net-_D319-Pad6_ APA102
D343 Net-_D343-Pad1_ Net-_D319-Pad1_ Net-_D319-Pad6_ GND VCC Net-_D343-Pad6_ APA102
D367 Net-_D367-Pad1_ Net-_D343-Pad1_ Net-_D343-Pad6_ GND VCC Net-_D367-Pad6_ APA102
D391 Net-_D391-Pad1_ Net-_D367-Pad1_ Net-_D367-Pad6_ GND VCC Net-_D391-Pad6_ APA102
D415 Net-_D415-Pad1_ Net-_D391-Pad1_ Net-_D391-Pad6_ GND VCC Net-_D415-Pad6_ APA102
D439 Net-_D439-Pad1_ Net-_D415-Pad1_ Net-_D415-Pad6_ GND VCC Net-_D439-Pad6_ APA102
D463 Net-_D463-Pad1_ Net-_D439-Pad1_ Net-_D439-Pad6_ GND VCC Net-_D463-Pad6_ APA102
D487 Net-_D487-Pad1_ Net-_D463-Pad1_ Net-_D463-Pad6_ GND VCC Net-_D487-Pad6_ APA102
D511 Net-_D511-Pad1_ Net-_D487-Pad1_ Net-_D487-Pad6_ GND VCC Net-_D511-Pad6_ APA102
D535 Net-_D535-Pad1_ Net-_D511-Pad1_ Net-_D511-Pad6_ GND VCC Net-_D535-Pad6_ APA102
D559 Net-_D559-Pad1_ Net-_D535-Pad1_ Net-_D535-Pad6_ GND VCC Net-_D559-Pad6_ APA102
D8 Net-_D32-Pad2_ Net-_D559-Pad1_ Net-_D559-Pad6_ GND VCC Net-_D32-Pad3_ APA102
D32 Net-_D32-Pad1_ Net-_D32-Pad2_ Net-_D32-Pad3_ GND VCC Net-_D32-Pad6_ APA102
D56 Net-_D56-Pad1_ Net-_D32-Pad1_ Net-_D32-Pad6_ GND VCC Net-_D56-Pad6_ APA102
D80 Net-_D104-Pad2_ Net-_D56-Pad1_ Net-_D56-Pad6_ GND VCC Net-_D104-Pad3_ APA102
D104 Net-_D104-Pad1_ Net-_D104-Pad2_ Net-_D104-Pad3_ GND VCC Net-_D104-Pad6_ APA102
D128 Net-_D128-Pad1_ Net-_D104-Pad1_ Net-_D104-Pad6_ GND VCC Net-_D128-Pad6_ APA102
D152 Net-_D152-Pad1_ Net-_D128-Pad1_ Net-_D128-Pad6_ GND VCC Net-_D152-Pad6_ APA102
D176 Net-_D176-Pad1_ Net-_D152-Pad1_ Net-_D152-Pad6_ GND VCC Net-_D176-Pad6_ APA102
D200 Net-_D200-Pad1_ Net-_D176-Pad1_ Net-_D176-Pad6_ GND VCC Net-_D200-Pad6_ APA102
D224 Net-_D224-Pad1_ Net-_D200-Pad1_ Net-_D200-Pad6_ GND VCC Net-_D224-Pad6_ APA102
D248 Net-_D248-Pad1_ Net-_D224-Pad1_ Net-_D224-Pad6_ GND VCC Net-_D248-Pad6_ APA102
D272 Net-_D272-Pad1_ Net-_D248-Pad1_ Net-_D248-Pad6_ GND VCC Net-_D272-Pad6_ APA102
D296 Net-_D296-Pad1_ Net-_D272-Pad1_ Net-_D272-Pad6_ GND VCC Net-_D296-Pad6_ APA102
D320 Net-_D320-Pad1_ Net-_D296-Pad1_ Net-_D296-Pad6_ GND VCC Net-_D320-Pad6_ APA102
D344 Net-_D344-Pad1_ Net-_D320-Pad1_ Net-_D320-Pad6_ GND VCC Net-_D344-Pad6_ APA102
D368 Net-_D368-Pad1_ Net-_D344-Pad1_ Net-_D344-Pad6_ GND VCC Net-_D368-Pad6_ APA102
D392 Net-_D392-Pad1_ Net-_D368-Pad1_ Net-_D368-Pad6_ GND VCC Net-_D392-Pad6_ APA102
D416 Net-_D416-Pad1_ Net-_D392-Pad1_ Net-_D392-Pad6_ GND VCC Net-_D416-Pad6_ APA102
D440 Net-_D440-Pad1_ Net-_D416-Pad1_ Net-_D416-Pad6_ GND VCC Net-_D440-Pad6_ APA102
D464 Net-_D464-Pad1_ Net-_D440-Pad1_ Net-_D440-Pad6_ GND VCC Net-_D464-Pad6_ APA102
D488 Net-_D488-Pad1_ Net-_D464-Pad1_ Net-_D464-Pad6_ GND VCC Net-_D488-Pad6_ APA102
D512 Net-_D512-Pad1_ Net-_D488-Pad1_ Net-_D488-Pad6_ GND VCC Net-_D512-Pad6_ APA102
D536 Net-_D536-Pad1_ Net-_D512-Pad1_ Net-_D512-Pad6_ GND VCC Net-_D536-Pad6_ APA102
D560 Net-_D560-Pad1_ Net-_D536-Pad1_ Net-_D536-Pad6_ GND VCC Net-_D560-Pad6_ APA102
D9 Net-_D33-Pad2_ Net-_D560-Pad1_ Net-_D560-Pad6_ GND VCC Net-_D33-Pad3_ APA102
D33 Net-_D33-Pad1_ Net-_D33-Pad2_ Net-_D33-Pad3_ GND VCC Net-_D33-Pad6_ APA102
D57 Net-_D57-Pad1_ Net-_D33-Pad1_ Net-_D33-Pad6_ GND VCC Net-_D57-Pad6_ APA102
D81 Net-_D105-Pad2_ Net-_D57-Pad1_ Net-_D57-Pad6_ GND VCC Net-_D105-Pad3_ APA102
D105 Net-_D105-Pad1_ Net-_D105-Pad2_ Net-_D105-Pad3_ GND VCC Net-_D105-Pad6_ APA102
D129 Net-_D129-Pad1_ Net-_D105-Pad1_ Net-_D105-Pad6_ GND VCC Net-_D129-Pad6_ APA102
D153 Net-_D153-Pad1_ Net-_D129-Pad1_ Net-_D129-Pad6_ GND VCC Net-_D153-Pad6_ APA102
D177 Net-_D177-Pad1_ Net-_D153-Pad1_ Net-_D153-Pad6_ GND VCC Net-_D177-Pad6_ APA102
D201 Net-_D201-Pad1_ Net-_D177-Pad1_ Net-_D177-Pad6_ GND VCC Net-_D201-Pad6_ APA102
D225 Net-_D225-Pad1_ Net-_D201-Pad1_ Net-_D201-Pad6_ GND VCC Net-_D225-Pad6_ APA102
D249 Net-_D249-Pad1_ Net-_D225-Pad1_ Net-_D225-Pad6_ GND VCC Net-_D249-Pad6_ APA102
D273 Net-_D273-Pad1_ Net-_D249-Pad1_ Net-_D249-Pad6_ GND VCC Net-_D273-Pad6_ APA102
D297 Net-_D297-Pad1_ Net-_D273-Pad1_ Net-_D273-Pad6_ GND VCC Net-_D297-Pad6_ APA102
D321 Net-_D321-Pad1_ Net-_D297-Pad1_ Net-_D297-Pad6_ GND VCC Net-_D321-Pad6_ APA102
D345 Net-_D345-Pad1_ Net-_D321-Pad1_ Net-_D321-Pad6_ GND VCC Net-_D345-Pad6_ APA102
D369 Net-_D369-Pad1_ Net-_D345-Pad1_ Net-_D345-Pad6_ GND VCC Net-_D369-Pad6_ APA102
D393 Net-_D393-Pad1_ Net-_D369-Pad1_ Net-_D369-Pad6_ GND VCC Net-_D393-Pad6_ APA102
D417 Net-_D417-Pad1_ Net-_D393-Pad1_ Net-_D393-Pad6_ GND VCC Net-_D417-Pad6_ APA102
D441 Net-_D441-Pad1_ Net-_D417-Pad1_ Net-_D417-Pad6_ GND VCC Net-_D441-Pad6_ APA102
D465 Net-_D465-Pad1_ Net-_D441-Pad1_ Net-_D441-Pad6_ GND VCC Net-_D465-Pad6_ APA102
D489 Net-_D489-Pad1_ Net-_D465-Pad1_ Net-_D465-Pad6_ GND VCC Net-_D489-Pad6_ APA102
D513 Net-_D513-Pad1_ Net-_D489-Pad1_ Net-_D489-Pad6_ GND VCC Net-_D513-Pad6_ APA102
D537 Net-_D537-Pad1_ Net-_D513-Pad1_ Net-_D513-Pad6_ GND VCC Net-_D537-Pad6_ APA102
D561 Net-_D10-Pad2_ Net-_D537-Pad1_ Net-_D537-Pad6_ GND VCC Net-_D10-Pad3_ APA102
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ Net-_D10-Pad3_ GND VCC Net-_D10-Pad6_ APA102
D34 Net-_D34-Pad1_ Net-_D10-Pad1_ Net-_D10-Pad6_ GND VCC Net-_D34-Pad6_ APA102
D58 Net-_D58-Pad1_ Net-_D34-Pad1_ Net-_D34-Pad6_ GND VCC Net-_D58-Pad6_ APA102
D82 Net-_D106-Pad2_ Net-_D58-Pad1_ Net-_D58-Pad6_ GND VCC Net-_D106-Pad3_ APA102
D106 Net-_D106-Pad1_ Net-_D106-Pad2_ Net-_D106-Pad3_ GND VCC Net-_D106-Pad6_ APA102
D130 Net-_D130-Pad1_ Net-_D106-Pad1_ Net-_D106-Pad6_ GND VCC Net-_D130-Pad6_ APA102
D154 Net-_D154-Pad1_ Net-_D130-Pad1_ Net-_D130-Pad6_ GND VCC Net-_D154-Pad6_ APA102
D178 Net-_D178-Pad1_ Net-_D154-Pad1_ Net-_D154-Pad6_ GND VCC Net-_D178-Pad6_ APA102
D202 Net-_D202-Pad1_ Net-_D178-Pad1_ Net-_D178-Pad6_ GND VCC Net-_D202-Pad6_ APA102
D226 Net-_D226-Pad1_ Net-_D202-Pad1_ Net-_D202-Pad6_ GND VCC Net-_D226-Pad6_ APA102
D250 Net-_D250-Pad1_ Net-_D226-Pad1_ Net-_D226-Pad6_ GND VCC Net-_D250-Pad6_ APA102
D274 Net-_D274-Pad1_ Net-_D250-Pad1_ Net-_D250-Pad6_ GND VCC Net-_D274-Pad6_ APA102
D298 Net-_D298-Pad1_ Net-_D274-Pad1_ Net-_D274-Pad6_ GND VCC Net-_D298-Pad6_ APA102
D322 Net-_D322-Pad1_ Net-_D298-Pad1_ Net-_D298-Pad6_ GND VCC Net-_D322-Pad6_ APA102
D346 Net-_D346-Pad1_ Net-_D322-Pad1_ Net-_D322-Pad6_ GND VCC Net-_D346-Pad6_ APA102
D370 Net-_D370-Pad1_ Net-_D346-Pad1_ Net-_D346-Pad6_ GND VCC Net-_D370-Pad6_ APA102
D394 Net-_D394-Pad1_ Net-_D370-Pad1_ Net-_D370-Pad6_ GND VCC Net-_D394-Pad6_ APA102
D418 Net-_D418-Pad1_ Net-_D394-Pad1_ Net-_D394-Pad6_ GND VCC Net-_D418-Pad6_ APA102
D442 Net-_D442-Pad1_ Net-_D418-Pad1_ Net-_D418-Pad6_ GND VCC Net-_D442-Pad6_ APA102
D466 Net-_D466-Pad1_ Net-_D442-Pad1_ Net-_D442-Pad6_ GND VCC Net-_D466-Pad6_ APA102
D490 Net-_D490-Pad1_ Net-_D466-Pad1_ Net-_D466-Pad6_ GND VCC Net-_D490-Pad6_ APA102
D514 Net-_D514-Pad1_ Net-_D490-Pad1_ Net-_D490-Pad6_ GND VCC Net-_D514-Pad6_ APA102
D538 Net-_D538-Pad1_ Net-_D514-Pad1_ Net-_D514-Pad6_ GND VCC Net-_D538-Pad6_ APA102
D562 Net-_D11-Pad2_ Net-_D538-Pad1_ Net-_D538-Pad6_ GND VCC Net-_D11-Pad3_ APA102
D11 Net-_D11-Pad1_ Net-_D11-Pad2_ Net-_D11-Pad3_ GND VCC Net-_D11-Pad6_ APA102
D35 Net-_D35-Pad1_ Net-_D11-Pad1_ Net-_D11-Pad6_ GND VCC Net-_D35-Pad6_ APA102
D59 Net-_D59-Pad1_ Net-_D35-Pad1_ Net-_D35-Pad6_ GND VCC Net-_D59-Pad6_ APA102
D83 Net-_D107-Pad2_ Net-_D59-Pad1_ Net-_D59-Pad6_ GND VCC Net-_D107-Pad3_ APA102
D107 Net-_D107-Pad1_ Net-_D107-Pad2_ Net-_D107-Pad3_ GND VCC Net-_D107-Pad6_ APA102
D131 Net-_D131-Pad1_ Net-_D107-Pad1_ Net-_D107-Pad6_ GND VCC Net-_D131-Pad6_ APA102
D155 Net-_D155-Pad1_ Net-_D131-Pad1_ Net-_D131-Pad6_ GND VCC Net-_D155-Pad6_ APA102
D179 Net-_D179-Pad1_ Net-_D155-Pad1_ Net-_D155-Pad6_ GND VCC Net-_D179-Pad6_ APA102
D203 Net-_D203-Pad1_ Net-_D179-Pad1_ Net-_D179-Pad6_ GND VCC Net-_D203-Pad6_ APA102
D227 Net-_D227-Pad1_ Net-_D203-Pad1_ Net-_D203-Pad6_ GND VCC Net-_D227-Pad6_ APA102
D251 Net-_D251-Pad1_ Net-_D227-Pad1_ Net-_D227-Pad6_ GND VCC Net-_D251-Pad6_ APA102
D275 Net-_D275-Pad1_ Net-_D251-Pad1_ Net-_D251-Pad6_ GND VCC Net-_D275-Pad6_ APA102
D299 Net-_D299-Pad1_ Net-_D275-Pad1_ Net-_D275-Pad6_ GND VCC Net-_D299-Pad6_ APA102
D323 Net-_D323-Pad1_ Net-_D299-Pad1_ Net-_D299-Pad6_ GND VCC Net-_D323-Pad6_ APA102
D347 Net-_D347-Pad1_ Net-_D323-Pad1_ Net-_D323-Pad6_ GND VCC Net-_D347-Pad6_ APA102
D371 Net-_D371-Pad1_ Net-_D347-Pad1_ Net-_D347-Pad6_ GND VCC Net-_D371-Pad6_ APA102
D395 Net-_D395-Pad1_ Net-_D371-Pad1_ Net-_D371-Pad6_ GND VCC Net-_D395-Pad6_ APA102
D419 Net-_D419-Pad1_ Net-_D395-Pad1_ Net-_D395-Pad6_ GND VCC Net-_D419-Pad6_ APA102
D443 Net-_D443-Pad1_ Net-_D419-Pad1_ Net-_D419-Pad6_ GND VCC Net-_D443-Pad6_ APA102
D467 Net-_D467-Pad1_ Net-_D443-Pad1_ Net-_D443-Pad6_ GND VCC Net-_D467-Pad6_ APA102
D491 Net-_D491-Pad1_ Net-_D467-Pad1_ Net-_D467-Pad6_ GND VCC Net-_D491-Pad6_ APA102
D515 Net-_D515-Pad1_ Net-_D491-Pad1_ Net-_D491-Pad6_ GND VCC Net-_D515-Pad6_ APA102
D539 Net-_D539-Pad1_ Net-_D515-Pad1_ Net-_D515-Pad6_ GND VCC Net-_D539-Pad6_ APA102
D563 Net-_D12-Pad2_ Net-_D539-Pad1_ Net-_D539-Pad6_ GND VCC Net-_D12-Pad3_ APA102
D12 Net-_D12-Pad1_ Net-_D12-Pad2_ Net-_D12-Pad3_ GND VCC Net-_D12-Pad6_ APA102
D36 Net-_D36-Pad1_ Net-_D12-Pad1_ Net-_D12-Pad6_ GND VCC Net-_D36-Pad6_ APA102
D60 Net-_D60-Pad1_ Net-_D36-Pad1_ Net-_D36-Pad6_ GND VCC Net-_D60-Pad6_ APA102
D84 Net-_D108-Pad2_ Net-_D60-Pad1_ Net-_D60-Pad6_ GND VCC Net-_D108-Pad3_ APA102
D108 Net-_D108-Pad1_ Net-_D108-Pad2_ Net-_D108-Pad3_ GND VCC Net-_D108-Pad6_ APA102
D132 Net-_D132-Pad1_ Net-_D108-Pad1_ Net-_D108-Pad6_ GND VCC Net-_D132-Pad6_ APA102
D156 Net-_D156-Pad1_ Net-_D132-Pad1_ Net-_D132-Pad6_ GND VCC Net-_D156-Pad6_ APA102
D180 Net-_D180-Pad1_ Net-_D156-Pad1_ Net-_D156-Pad6_ GND VCC Net-_D180-Pad6_ APA102
D204 Net-_D204-Pad1_ Net-_D180-Pad1_ Net-_D180-Pad6_ GND VCC Net-_D204-Pad6_ APA102
D228 Net-_D228-Pad1_ Net-_D204-Pad1_ Net-_D204-Pad6_ GND VCC Net-_D228-Pad6_ APA102
D252 Net-_D252-Pad1_ Net-_D228-Pad1_ Net-_D228-Pad6_ GND VCC Net-_D252-Pad6_ APA102
D276 Net-_D276-Pad1_ Net-_D252-Pad1_ Net-_D252-Pad6_ GND VCC Net-_D276-Pad6_ APA102
D300 Net-_D300-Pad1_ Net-_D276-Pad1_ Net-_D276-Pad6_ GND VCC Net-_D300-Pad6_ APA102
D324 Net-_D324-Pad1_ Net-_D300-Pad1_ Net-_D300-Pad6_ GND VCC Net-_D324-Pad6_ APA102
D348 Net-_D348-Pad1_ Net-_D324-Pad1_ Net-_D324-Pad6_ GND VCC Net-_D348-Pad6_ APA102
D372 Net-_D372-Pad1_ Net-_D348-Pad1_ Net-_D348-Pad6_ GND VCC Net-_D372-Pad6_ APA102
D396 Net-_D396-Pad1_ Net-_D372-Pad1_ Net-_D372-Pad6_ GND VCC Net-_D396-Pad6_ APA102
D420 Net-_D420-Pad1_ Net-_D396-Pad1_ Net-_D396-Pad6_ GND VCC Net-_D420-Pad6_ APA102
D444 Net-_D444-Pad1_ Net-_D420-Pad1_ Net-_D420-Pad6_ GND VCC Net-_D444-Pad6_ APA102
D468 Net-_D468-Pad1_ Net-_D444-Pad1_ Net-_D444-Pad6_ GND VCC Net-_D468-Pad6_ APA102
D492 Net-_D492-Pad1_ Net-_D468-Pad1_ Net-_D468-Pad6_ GND VCC Net-_D492-Pad6_ APA102
D516 Net-_D516-Pad1_ Net-_D492-Pad1_ Net-_D492-Pad6_ GND VCC Net-_D516-Pad6_ APA102
D540 Net-_D540-Pad1_ Net-_D516-Pad1_ Net-_D516-Pad6_ GND VCC Net-_D540-Pad6_ APA102
D564 Net-_D13-Pad2_ Net-_D540-Pad1_ Net-_D540-Pad6_ GND VCC Net-_D13-Pad3_ APA102
D13 Net-_D13-Pad1_ Net-_D13-Pad2_ Net-_D13-Pad3_ GND VCC Net-_D13-Pad6_ APA102
D37 Net-_D37-Pad1_ Net-_D13-Pad1_ Net-_D13-Pad6_ GND VCC Net-_D37-Pad6_ APA102
D61 Net-_D61-Pad1_ Net-_D37-Pad1_ Net-_D37-Pad6_ GND VCC Net-_D61-Pad6_ APA102
D85 Net-_D109-Pad2_ Net-_D61-Pad1_ Net-_D61-Pad6_ GND VCC Net-_D109-Pad3_ APA102
D109 Net-_D109-Pad1_ Net-_D109-Pad2_ Net-_D109-Pad3_ GND VCC Net-_D109-Pad6_ APA102
D133 Net-_D133-Pad1_ Net-_D109-Pad1_ Net-_D109-Pad6_ GND VCC Net-_D133-Pad6_ APA102
D157 Net-_D157-Pad1_ Net-_D133-Pad1_ Net-_D133-Pad6_ GND VCC Net-_D157-Pad6_ APA102
D181 Net-_D181-Pad1_ Net-_D157-Pad1_ Net-_D157-Pad6_ GND VCC Net-_D181-Pad6_ APA102
D205 Net-_D205-Pad1_ Net-_D181-Pad1_ Net-_D181-Pad6_ GND VCC Net-_D205-Pad6_ APA102
D229 Net-_D229-Pad1_ Net-_D205-Pad1_ Net-_D205-Pad6_ GND VCC Net-_D229-Pad6_ APA102
D253 Net-_D253-Pad1_ Net-_D229-Pad1_ Net-_D229-Pad6_ GND VCC Net-_D253-Pad6_ APA102
D277 Net-_D277-Pad1_ Net-_D253-Pad1_ Net-_D253-Pad6_ GND VCC Net-_D277-Pad6_ APA102
D301 Net-_D301-Pad1_ Net-_D277-Pad1_ Net-_D277-Pad6_ GND VCC Net-_D301-Pad6_ APA102
D325 Net-_D325-Pad1_ Net-_D301-Pad1_ Net-_D301-Pad6_ GND VCC Net-_D325-Pad6_ APA102
D349 Net-_D349-Pad1_ Net-_D325-Pad1_ Net-_D325-Pad6_ GND VCC Net-_D349-Pad6_ APA102
D373 Net-_D373-Pad1_ Net-_D349-Pad1_ Net-_D349-Pad6_ GND VCC Net-_D373-Pad6_ APA102
D397 Net-_D397-Pad1_ Net-_D373-Pad1_ Net-_D373-Pad6_ GND VCC Net-_D397-Pad6_ APA102
D421 Net-_D421-Pad1_ Net-_D397-Pad1_ Net-_D397-Pad6_ GND VCC Net-_D421-Pad6_ APA102
D445 Net-_D445-Pad1_ Net-_D421-Pad1_ Net-_D421-Pad6_ GND VCC Net-_D445-Pad6_ APA102
D469 Net-_D469-Pad1_ Net-_D445-Pad1_ Net-_D445-Pad6_ GND VCC Net-_D469-Pad6_ APA102
D493 Net-_D493-Pad1_ Net-_D469-Pad1_ Net-_D469-Pad6_ GND VCC Net-_D493-Pad6_ APA102
D517 Net-_D517-Pad1_ Net-_D493-Pad1_ Net-_D493-Pad6_ GND VCC Net-_D517-Pad6_ APA102
D541 Net-_D541-Pad1_ Net-_D517-Pad1_ Net-_D517-Pad6_ GND VCC Net-_D541-Pad6_ APA102
D565 Net-_D14-Pad2_ Net-_D541-Pad1_ Net-_D541-Pad6_ GND VCC Net-_D14-Pad3_ APA102
D14 Net-_D14-Pad1_ Net-_D14-Pad2_ Net-_D14-Pad3_ GND VCC Net-_D14-Pad6_ APA102
D38 Net-_D38-Pad1_ Net-_D14-Pad1_ Net-_D14-Pad6_ GND VCC Net-_D38-Pad6_ APA102
D62 Net-_D62-Pad1_ Net-_D38-Pad1_ Net-_D38-Pad6_ GND VCC Net-_D62-Pad6_ APA102
D86 Net-_D110-Pad2_ Net-_D62-Pad1_ Net-_D62-Pad6_ GND VCC Net-_D110-Pad3_ APA102
D110 Net-_D110-Pad1_ Net-_D110-Pad2_ Net-_D110-Pad3_ GND VCC Net-_D110-Pad6_ APA102
D134 Net-_D134-Pad1_ Net-_D110-Pad1_ Net-_D110-Pad6_ GND VCC Net-_D134-Pad6_ APA102
D158 Net-_D158-Pad1_ Net-_D134-Pad1_ Net-_D134-Pad6_ GND VCC Net-_D158-Pad6_ APA102
D182 Net-_D182-Pad1_ Net-_D158-Pad1_ Net-_D158-Pad6_ GND VCC Net-_D182-Pad6_ APA102
D206 Net-_D206-Pad1_ Net-_D182-Pad1_ Net-_D182-Pad6_ GND VCC Net-_D206-Pad6_ APA102
D230 Net-_D230-Pad1_ Net-_D206-Pad1_ Net-_D206-Pad6_ GND VCC Net-_D230-Pad6_ APA102
D254 Net-_D254-Pad1_ Net-_D230-Pad1_ Net-_D230-Pad6_ GND VCC Net-_D254-Pad6_ APA102
D278 Net-_D278-Pad1_ Net-_D254-Pad1_ Net-_D254-Pad6_ GND VCC Net-_D278-Pad6_ APA102
D302 Net-_D302-Pad1_ Net-_D278-Pad1_ Net-_D278-Pad6_ GND VCC Net-_D302-Pad6_ APA102
D326 Net-_D326-Pad1_ Net-_D302-Pad1_ Net-_D302-Pad6_ GND VCC Net-_D326-Pad6_ APA102
D350 Net-_D350-Pad1_ Net-_D326-Pad1_ Net-_D326-Pad6_ GND VCC Net-_D350-Pad6_ APA102
D374 Net-_D374-Pad1_ Net-_D350-Pad1_ Net-_D350-Pad6_ GND VCC Net-_D374-Pad6_ APA102
D398 Net-_D398-Pad1_ Net-_D374-Pad1_ Net-_D374-Pad6_ GND VCC Net-_D398-Pad6_ APA102
D422 Net-_D422-Pad1_ Net-_D398-Pad1_ Net-_D398-Pad6_ GND VCC Net-_D422-Pad6_ APA102
D446 Net-_D446-Pad1_ Net-_D422-Pad1_ Net-_D422-Pad6_ GND VCC Net-_D446-Pad6_ APA102
D470 Net-_D470-Pad1_ Net-_D446-Pad1_ Net-_D446-Pad6_ GND VCC Net-_D470-Pad6_ APA102
D494 Net-_D494-Pad1_ Net-_D470-Pad1_ Net-_D470-Pad6_ GND VCC Net-_D494-Pad6_ APA102
D518 Net-_D518-Pad1_ Net-_D494-Pad1_ Net-_D494-Pad6_ GND VCC Net-_D518-Pad6_ APA102
D542 Net-_D542-Pad1_ Net-_D518-Pad1_ Net-_D518-Pad6_ GND VCC Net-_D542-Pad6_ APA102
D566 Net-_D15-Pad2_ Net-_D542-Pad1_ Net-_D542-Pad6_ GND VCC Net-_D15-Pad3_ APA102
D15 Net-_D15-Pad1_ Net-_D15-Pad2_ Net-_D15-Pad3_ GND VCC Net-_D15-Pad6_ APA102
D39 Net-_D39-Pad1_ Net-_D15-Pad1_ Net-_D15-Pad6_ GND VCC Net-_D39-Pad6_ APA102
D63 Net-_D63-Pad1_ Net-_D39-Pad1_ Net-_D39-Pad6_ GND VCC Net-_D63-Pad6_ APA102
D87 Net-_D111-Pad2_ Net-_D63-Pad1_ Net-_D63-Pad6_ GND VCC Net-_D111-Pad3_ APA102
D111 Net-_D111-Pad1_ Net-_D111-Pad2_ Net-_D111-Pad3_ GND VCC Net-_D111-Pad6_ APA102
D135 Net-_D135-Pad1_ Net-_D111-Pad1_ Net-_D111-Pad6_ GND VCC Net-_D135-Pad6_ APA102
D159 Net-_D159-Pad1_ Net-_D135-Pad1_ Net-_D135-Pad6_ GND VCC Net-_D159-Pad6_ APA102
D183 Net-_D183-Pad1_ Net-_D159-Pad1_ Net-_D159-Pad6_ GND VCC Net-_D183-Pad6_ APA102
D207 Net-_D207-Pad1_ Net-_D183-Pad1_ Net-_D183-Pad6_ GND VCC Net-_D207-Pad6_ APA102
D231 Net-_D231-Pad1_ Net-_D207-Pad1_ Net-_D207-Pad6_ GND VCC Net-_D231-Pad6_ APA102
D255 Net-_D255-Pad1_ Net-_D231-Pad1_ Net-_D231-Pad6_ GND VCC Net-_D255-Pad6_ APA102
D279 Net-_D279-Pad1_ Net-_D255-Pad1_ Net-_D255-Pad6_ GND VCC Net-_D279-Pad6_ APA102
D303 Net-_D303-Pad1_ Net-_D279-Pad1_ Net-_D279-Pad6_ GND VCC Net-_D303-Pad6_ APA102
D327 Net-_D327-Pad1_ Net-_D303-Pad1_ Net-_D303-Pad6_ GND VCC Net-_D327-Pad6_ APA102
D351 Net-_D351-Pad1_ Net-_D327-Pad1_ Net-_D327-Pad6_ GND VCC Net-_D351-Pad6_ APA102
D375 Net-_D375-Pad1_ Net-_D351-Pad1_ Net-_D351-Pad6_ GND VCC Net-_D375-Pad6_ APA102
D399 Net-_D399-Pad1_ Net-_D375-Pad1_ Net-_D375-Pad6_ GND VCC Net-_D399-Pad6_ APA102
D423 Net-_D423-Pad1_ Net-_D399-Pad1_ Net-_D399-Pad6_ GND VCC Net-_D423-Pad6_ APA102
D447 Net-_D447-Pad1_ Net-_D423-Pad1_ Net-_D423-Pad6_ GND VCC Net-_D447-Pad6_ APA102
D471 Net-_D471-Pad1_ Net-_D447-Pad1_ Net-_D447-Pad6_ GND VCC Net-_D471-Pad6_ APA102
D495 Net-_D495-Pad1_ Net-_D471-Pad1_ Net-_D471-Pad6_ GND VCC Net-_D495-Pad6_ APA102
D519 Net-_D519-Pad1_ Net-_D495-Pad1_ Net-_D495-Pad6_ GND VCC Net-_D519-Pad6_ APA102
D543 Net-_D543-Pad1_ Net-_D519-Pad1_ Net-_D519-Pad6_ GND VCC Net-_D543-Pad6_ APA102
D567 Net-_D16-Pad2_ Net-_D543-Pad1_ Net-_D543-Pad6_ GND VCC Net-_D16-Pad3_ APA102
D16 Net-_D16-Pad1_ Net-_D16-Pad2_ Net-_D16-Pad3_ GND VCC Net-_D16-Pad6_ APA102
D40 Net-_D40-Pad1_ Net-_D16-Pad1_ Net-_D16-Pad6_ GND VCC Net-_D40-Pad6_ APA102
D64 Net-_D64-Pad1_ Net-_D40-Pad1_ Net-_D40-Pad6_ GND VCC Net-_D64-Pad6_ APA102
D88 Net-_D112-Pad2_ Net-_D64-Pad1_ Net-_D64-Pad6_ GND VCC Net-_D112-Pad3_ APA102
D112 Net-_D112-Pad1_ Net-_D112-Pad2_ Net-_D112-Pad3_ GND VCC Net-_D112-Pad6_ APA102
D136 Net-_D136-Pad1_ Net-_D112-Pad1_ Net-_D112-Pad6_ GND VCC Net-_D136-Pad6_ APA102
D160 Net-_D160-Pad1_ Net-_D136-Pad1_ Net-_D136-Pad6_ GND VCC Net-_D160-Pad6_ APA102
D184 Net-_D184-Pad1_ Net-_D160-Pad1_ Net-_D160-Pad6_ GND VCC Net-_D184-Pad6_ APA102
D208 Net-_D208-Pad1_ Net-_D184-Pad1_ Net-_D184-Pad6_ GND VCC Net-_D208-Pad6_ APA102
D232 Net-_D232-Pad1_ Net-_D208-Pad1_ Net-_D208-Pad6_ GND VCC Net-_D232-Pad6_ APA102
D256 Net-_D256-Pad1_ Net-_D232-Pad1_ Net-_D232-Pad6_ GND VCC Net-_D256-Pad6_ APA102
D280 Net-_D280-Pad1_ Net-_D256-Pad1_ Net-_D256-Pad6_ GND VCC Net-_D280-Pad6_ APA102
D304 Net-_D304-Pad1_ Net-_D280-Pad1_ Net-_D280-Pad6_ GND VCC Net-_D304-Pad6_ APA102
D328 Net-_D328-Pad1_ Net-_D304-Pad1_ Net-_D304-Pad6_ GND VCC Net-_D328-Pad6_ APA102
D352 Net-_D352-Pad1_ Net-_D328-Pad1_ Net-_D328-Pad6_ GND VCC Net-_D352-Pad6_ APA102
D376 Net-_D376-Pad1_ Net-_D352-Pad1_ Net-_D352-Pad6_ GND VCC Net-_D376-Pad6_ APA102
D400 Net-_D400-Pad1_ Net-_D376-Pad1_ Net-_D376-Pad6_ GND VCC Net-_D400-Pad6_ APA102
D424 Net-_D424-Pad1_ Net-_D400-Pad1_ Net-_D400-Pad6_ GND VCC Net-_D424-Pad6_ APA102
D448 Net-_D448-Pad1_ Net-_D424-Pad1_ Net-_D424-Pad6_ GND VCC Net-_D448-Pad6_ APA102
D472 Net-_D472-Pad1_ Net-_D448-Pad1_ Net-_D448-Pad6_ GND VCC Net-_D472-Pad6_ APA102
D496 Net-_D496-Pad1_ Net-_D472-Pad1_ Net-_D472-Pad6_ GND VCC Net-_D496-Pad6_ APA102
D520 Net-_D520-Pad1_ Net-_D496-Pad1_ Net-_D496-Pad6_ GND VCC Net-_D520-Pad6_ APA102
D544 Net-_D544-Pad1_ Net-_D520-Pad1_ Net-_D520-Pad6_ GND VCC Net-_D544-Pad6_ APA102
D568 Net-_D17-Pad2_ Net-_D544-Pad1_ Net-_D544-Pad6_ GND VCC Net-_D17-Pad3_ APA102
D17 Net-_D17-Pad1_ Net-_D17-Pad2_ Net-_D17-Pad3_ GND VCC Net-_D17-Pad6_ APA102
D41 Net-_D41-Pad1_ Net-_D17-Pad1_ Net-_D17-Pad6_ GND VCC Net-_D41-Pad6_ APA102
D65 Net-_D65-Pad1_ Net-_D41-Pad1_ Net-_D41-Pad6_ GND VCC Net-_D65-Pad6_ APA102
D89 Net-_D113-Pad2_ Net-_D65-Pad1_ Net-_D65-Pad6_ GND VCC Net-_D113-Pad3_ APA102
D113 Net-_D113-Pad1_ Net-_D113-Pad2_ Net-_D113-Pad3_ GND VCC Net-_D113-Pad6_ APA102
D137 Net-_D137-Pad1_ Net-_D113-Pad1_ Net-_D113-Pad6_ GND VCC Net-_D137-Pad6_ APA102
D161 Net-_D161-Pad1_ Net-_D137-Pad1_ Net-_D137-Pad6_ GND VCC Net-_D161-Pad6_ APA102
D185 Net-_D185-Pad1_ Net-_D161-Pad1_ Net-_D161-Pad6_ GND VCC Net-_D185-Pad6_ APA102
D209 Net-_D209-Pad1_ Net-_D185-Pad1_ Net-_D185-Pad6_ GND VCC Net-_D209-Pad6_ APA102
D233 Net-_D233-Pad1_ Net-_D209-Pad1_ Net-_D209-Pad6_ GND VCC Net-_D233-Pad6_ APA102
D257 Net-_D257-Pad1_ Net-_D233-Pad1_ Net-_D233-Pad6_ GND VCC Net-_D257-Pad6_ APA102
D281 Net-_D281-Pad1_ Net-_D257-Pad1_ Net-_D257-Pad6_ GND VCC Net-_D281-Pad6_ APA102
D305 Net-_D305-Pad1_ Net-_D281-Pad1_ Net-_D281-Pad6_ GND VCC Net-_D305-Pad6_ APA102
D329 Net-_D329-Pad1_ Net-_D305-Pad1_ Net-_D305-Pad6_ GND VCC Net-_D329-Pad6_ APA102
D353 Net-_D353-Pad1_ Net-_D329-Pad1_ Net-_D329-Pad6_ GND VCC Net-_D353-Pad6_ APA102
D377 Net-_D377-Pad1_ Net-_D353-Pad1_ Net-_D353-Pad6_ GND VCC Net-_D377-Pad6_ APA102
D401 Net-_D401-Pad1_ Net-_D377-Pad1_ Net-_D377-Pad6_ GND VCC Net-_D401-Pad6_ APA102
D425 Net-_D425-Pad1_ Net-_D401-Pad1_ Net-_D401-Pad6_ GND VCC Net-_D425-Pad6_ APA102
D449 Net-_D449-Pad1_ Net-_D425-Pad1_ Net-_D425-Pad6_ GND VCC Net-_D449-Pad6_ APA102
D473 Net-_D473-Pad1_ Net-_D449-Pad1_ Net-_D449-Pad6_ GND VCC Net-_D473-Pad6_ APA102
D497 Net-_D497-Pad1_ Net-_D473-Pad1_ Net-_D473-Pad6_ GND VCC Net-_D497-Pad6_ APA102
D521 Net-_D521-Pad1_ Net-_D497-Pad1_ Net-_D497-Pad6_ GND VCC Net-_D521-Pad6_ APA102
D545 Net-_D545-Pad1_ Net-_D521-Pad1_ Net-_D521-Pad6_ GND VCC Net-_D545-Pad6_ APA102
D569 Net-_D18-Pad2_ Net-_D545-Pad1_ Net-_D545-Pad6_ GND VCC Net-_D18-Pad3_ APA102
D18 Net-_D18-Pad1_ Net-_D18-Pad2_ Net-_D18-Pad3_ GND VCC Net-_D18-Pad6_ APA102
D42 Net-_D42-Pad1_ Net-_D18-Pad1_ Net-_D18-Pad6_ GND VCC Net-_D42-Pad6_ APA102
D66 Net-_D66-Pad1_ Net-_D42-Pad1_ Net-_D42-Pad6_ GND VCC Net-_D66-Pad6_ APA102
D90 Net-_D114-Pad2_ Net-_D66-Pad1_ Net-_D66-Pad6_ GND VCC Net-_D114-Pad3_ APA102
D114 Net-_D114-Pad1_ Net-_D114-Pad2_ Net-_D114-Pad3_ GND VCC Net-_D114-Pad6_ APA102
D138 Net-_D138-Pad1_ Net-_D114-Pad1_ Net-_D114-Pad6_ GND VCC Net-_D138-Pad6_ APA102
D162 Net-_D162-Pad1_ Net-_D138-Pad1_ Net-_D138-Pad6_ GND VCC Net-_D162-Pad6_ APA102
D186 Net-_D186-Pad1_ Net-_D162-Pad1_ Net-_D162-Pad6_ GND VCC Net-_D186-Pad6_ APA102
D210 Net-_D210-Pad1_ Net-_D186-Pad1_ Net-_D186-Pad6_ GND VCC Net-_D210-Pad6_ APA102
D234 Net-_D234-Pad1_ Net-_D210-Pad1_ Net-_D210-Pad6_ GND VCC Net-_D234-Pad6_ APA102
D258 Net-_D258-Pad1_ Net-_D234-Pad1_ Net-_D234-Pad6_ GND VCC Net-_D258-Pad6_ APA102
D282 Net-_D282-Pad1_ Net-_D258-Pad1_ Net-_D258-Pad6_ GND VCC Net-_D282-Pad6_ APA102
D306 Net-_D306-Pad1_ Net-_D282-Pad1_ Net-_D282-Pad6_ GND VCC Net-_D306-Pad6_ APA102
D330 Net-_D330-Pad1_ Net-_D306-Pad1_ Net-_D306-Pad6_ GND VCC Net-_D330-Pad6_ APA102
D354 Net-_D354-Pad1_ Net-_D330-Pad1_ Net-_D330-Pad6_ GND VCC Net-_D354-Pad6_ APA102
D378 Net-_D378-Pad1_ Net-_D354-Pad1_ Net-_D354-Pad6_ GND VCC Net-_D378-Pad6_ APA102
D402 Net-_D402-Pad1_ Net-_D378-Pad1_ Net-_D378-Pad6_ GND VCC Net-_D402-Pad6_ APA102
D426 Net-_D426-Pad1_ Net-_D402-Pad1_ Net-_D402-Pad6_ GND VCC Net-_D426-Pad6_ APA102
D450 Net-_D450-Pad1_ Net-_D426-Pad1_ Net-_D426-Pad6_ GND VCC Net-_D450-Pad6_ APA102
D474 Net-_D474-Pad1_ Net-_D450-Pad1_ Net-_D450-Pad6_ GND VCC Net-_D474-Pad6_ APA102
D498 Net-_D498-Pad1_ Net-_D474-Pad1_ Net-_D474-Pad6_ GND VCC Net-_D498-Pad6_ APA102
D522 Net-_D522-Pad1_ Net-_D498-Pad1_ Net-_D498-Pad6_ GND VCC Net-_D522-Pad6_ APA102
D546 Net-_D546-Pad1_ Net-_D522-Pad1_ Net-_D522-Pad6_ GND VCC Net-_D546-Pad6_ APA102
D570 Net-_D19-Pad2_ Net-_D546-Pad1_ Net-_D546-Pad6_ GND VCC Net-_D19-Pad3_ APA102
D19 Net-_D19-Pad1_ Net-_D19-Pad2_ Net-_D19-Pad3_ GND VCC Net-_D19-Pad6_ APA102
D43 Net-_D43-Pad1_ Net-_D19-Pad1_ Net-_D19-Pad6_ GND VCC Net-_D43-Pad6_ APA102
D67 Net-_D67-Pad1_ Net-_D43-Pad1_ Net-_D43-Pad6_ GND VCC Net-_D67-Pad6_ APA102
D91 Net-_D115-Pad2_ Net-_D67-Pad1_ Net-_D67-Pad6_ GND VCC Net-_D115-Pad3_ APA102
D115 Net-_D115-Pad1_ Net-_D115-Pad2_ Net-_D115-Pad3_ GND VCC Net-_D115-Pad6_ APA102
D139 Net-_D139-Pad1_ Net-_D115-Pad1_ Net-_D115-Pad6_ GND VCC Net-_D139-Pad6_ APA102
D163 Net-_D163-Pad1_ Net-_D139-Pad1_ Net-_D139-Pad6_ GND VCC Net-_D163-Pad6_ APA102
D187 Net-_D187-Pad1_ Net-_D163-Pad1_ Net-_D163-Pad6_ GND VCC Net-_D187-Pad6_ APA102
D211 Net-_D211-Pad1_ Net-_D187-Pad1_ Net-_D187-Pad6_ GND VCC Net-_D211-Pad6_ APA102
D235 Net-_D235-Pad1_ Net-_D211-Pad1_ Net-_D211-Pad6_ GND VCC Net-_D235-Pad6_ APA102
D259 Net-_D259-Pad1_ Net-_D235-Pad1_ Net-_D235-Pad6_ GND VCC Net-_D259-Pad6_ APA102
D283 Net-_D283-Pad1_ Net-_D259-Pad1_ Net-_D259-Pad6_ GND VCC Net-_D283-Pad6_ APA102
D307 Net-_D307-Pad1_ Net-_D283-Pad1_ Net-_D283-Pad6_ GND VCC Net-_D307-Pad6_ APA102
D331 Net-_D331-Pad1_ Net-_D307-Pad1_ Net-_D307-Pad6_ GND VCC Net-_D331-Pad6_ APA102
D355 Net-_D355-Pad1_ Net-_D331-Pad1_ Net-_D331-Pad6_ GND VCC Net-_D355-Pad6_ APA102
D379 Net-_D379-Pad1_ Net-_D355-Pad1_ Net-_D355-Pad6_ GND VCC Net-_D379-Pad6_ APA102
D403 Net-_D403-Pad1_ Net-_D379-Pad1_ Net-_D379-Pad6_ GND VCC Net-_D403-Pad6_ APA102
D427 Net-_D427-Pad1_ Net-_D403-Pad1_ Net-_D403-Pad6_ GND VCC Net-_D427-Pad6_ APA102
D451 Net-_D451-Pad1_ Net-_D427-Pad1_ Net-_D427-Pad6_ GND VCC Net-_D451-Pad6_ APA102
D475 Net-_D475-Pad1_ Net-_D451-Pad1_ Net-_D451-Pad6_ GND VCC Net-_D475-Pad6_ APA102
D499 Net-_D499-Pad1_ Net-_D475-Pad1_ Net-_D475-Pad6_ GND VCC Net-_D499-Pad6_ APA102
D523 Net-_D523-Pad1_ Net-_D499-Pad1_ Net-_D499-Pad6_ GND VCC Net-_D523-Pad6_ APA102
D547 Net-_D547-Pad1_ Net-_D523-Pad1_ Net-_D523-Pad6_ GND VCC Net-_D547-Pad6_ APA102
D571 Net-_D20-Pad2_ Net-_D547-Pad1_ Net-_D547-Pad6_ GND VCC Net-_D20-Pad3_ APA102
D20 Net-_D20-Pad1_ Net-_D20-Pad2_ Net-_D20-Pad3_ GND VCC Net-_D20-Pad6_ APA102
D44 Net-_D44-Pad1_ Net-_D20-Pad1_ Net-_D20-Pad6_ GND VCC Net-_D44-Pad6_ APA102
D68 Net-_D68-Pad1_ Net-_D44-Pad1_ Net-_D44-Pad6_ GND VCC Net-_D68-Pad6_ APA102
D92 Net-_D116-Pad2_ Net-_D68-Pad1_ Net-_D68-Pad6_ GND VCC Net-_D116-Pad3_ APA102
D116 Net-_D116-Pad1_ Net-_D116-Pad2_ Net-_D116-Pad3_ GND VCC Net-_D116-Pad6_ APA102
D140 Net-_D140-Pad1_ Net-_D116-Pad1_ Net-_D116-Pad6_ GND VCC Net-_D140-Pad6_ APA102
D164 Net-_D164-Pad1_ Net-_D140-Pad1_ Net-_D140-Pad6_ GND VCC Net-_D164-Pad6_ APA102
D188 Net-_D188-Pad1_ Net-_D164-Pad1_ Net-_D164-Pad6_ GND VCC Net-_D188-Pad6_ APA102
D212 Net-_D212-Pad1_ Net-_D188-Pad1_ Net-_D188-Pad6_ GND VCC Net-_D212-Pad6_ APA102
D236 Net-_D236-Pad1_ Net-_D212-Pad1_ Net-_D212-Pad6_ GND VCC Net-_D236-Pad6_ APA102
D260 Net-_D260-Pad1_ Net-_D236-Pad1_ Net-_D236-Pad6_ GND VCC Net-_D260-Pad6_ APA102
D284 Net-_D284-Pad1_ Net-_D260-Pad1_ Net-_D260-Pad6_ GND VCC Net-_D284-Pad6_ APA102
D308 Net-_D308-Pad1_ Net-_D284-Pad1_ Net-_D284-Pad6_ GND VCC Net-_D308-Pad6_ APA102
D332 Net-_D332-Pad1_ Net-_D308-Pad1_ Net-_D308-Pad6_ GND VCC Net-_D332-Pad6_ APA102
D356 Net-_D356-Pad1_ Net-_D332-Pad1_ Net-_D332-Pad6_ GND VCC Net-_D356-Pad6_ APA102
D380 Net-_D380-Pad1_ Net-_D356-Pad1_ Net-_D356-Pad6_ GND VCC Net-_D380-Pad6_ APA102
D404 Net-_D404-Pad1_ Net-_D380-Pad1_ Net-_D380-Pad6_ GND VCC Net-_D404-Pad6_ APA102
D428 Net-_D428-Pad1_ Net-_D404-Pad1_ Net-_D404-Pad6_ GND VCC Net-_D428-Pad6_ APA102
D452 Net-_D452-Pad1_ Net-_D428-Pad1_ Net-_D428-Pad6_ GND VCC Net-_D452-Pad6_ APA102
D476 Net-_D476-Pad1_ Net-_D452-Pad1_ Net-_D452-Pad6_ GND VCC Net-_D476-Pad6_ APA102
D500 Net-_D500-Pad1_ Net-_D476-Pad1_ Net-_D476-Pad6_ GND VCC Net-_D500-Pad6_ APA102
D524 Net-_D524-Pad1_ Net-_D500-Pad1_ Net-_D500-Pad6_ GND VCC Net-_D524-Pad6_ APA102
D548 Net-_D548-Pad1_ Net-_D524-Pad1_ Net-_D524-Pad6_ GND VCC Net-_D548-Pad6_ APA102
D572 Net-_D21-Pad2_ Net-_D548-Pad1_ Net-_D548-Pad6_ GND VCC Net-_D21-Pad3_ APA102
D21 Net-_D21-Pad1_ Net-_D21-Pad2_ Net-_D21-Pad3_ GND VCC Net-_D21-Pad6_ APA102
D45 Net-_D45-Pad1_ Net-_D21-Pad1_ Net-_D21-Pad6_ GND VCC Net-_D45-Pad6_ APA102
D69 Net-_D69-Pad1_ Net-_D45-Pad1_ Net-_D45-Pad6_ GND VCC Net-_D69-Pad6_ APA102
D93 Net-_D117-Pad2_ Net-_D69-Pad1_ Net-_D69-Pad6_ GND VCC Net-_D117-Pad3_ APA102
D117 Net-_D117-Pad1_ Net-_D117-Pad2_ Net-_D117-Pad3_ GND VCC Net-_D117-Pad6_ APA102
D141 Net-_D141-Pad1_ Net-_D117-Pad1_ Net-_D117-Pad6_ GND VCC Net-_D141-Pad6_ APA102
D165 Net-_D165-Pad1_ Net-_D141-Pad1_ Net-_D141-Pad6_ GND VCC Net-_D165-Pad6_ APA102
D189 Net-_D189-Pad1_ Net-_D165-Pad1_ Net-_D165-Pad6_ GND VCC Net-_D189-Pad6_ APA102
D213 Net-_D213-Pad1_ Net-_D189-Pad1_ Net-_D189-Pad6_ GND VCC Net-_D213-Pad6_ APA102
D237 Net-_D237-Pad1_ Net-_D213-Pad1_ Net-_D213-Pad6_ GND VCC Net-_D237-Pad6_ APA102
D261 Net-_D261-Pad1_ Net-_D237-Pad1_ Net-_D237-Pad6_ GND VCC Net-_D261-Pad6_ APA102
D285 Net-_D285-Pad1_ Net-_D261-Pad1_ Net-_D261-Pad6_ GND VCC Net-_D285-Pad6_ APA102
D309 Net-_D309-Pad1_ Net-_D285-Pad1_ Net-_D285-Pad6_ GND VCC Net-_D309-Pad6_ APA102
D333 Net-_D333-Pad1_ Net-_D309-Pad1_ Net-_D309-Pad6_ GND VCC Net-_D333-Pad6_ APA102
D357 Net-_D357-Pad1_ Net-_D333-Pad1_ Net-_D333-Pad6_ GND VCC Net-_D357-Pad6_ APA102
D381 Net-_D381-Pad1_ Net-_D357-Pad1_ Net-_D357-Pad6_ GND VCC Net-_D381-Pad6_ APA102
D405 Net-_D405-Pad1_ Net-_D381-Pad1_ Net-_D381-Pad6_ GND VCC Net-_D405-Pad6_ APA102
D429 Net-_D429-Pad1_ Net-_D405-Pad1_ Net-_D405-Pad6_ GND VCC Net-_D429-Pad6_ APA102
D453 Net-_D453-Pad1_ Net-_D429-Pad1_ Net-_D429-Pad6_ GND VCC Net-_D453-Pad6_ APA102
D477 Net-_D477-Pad1_ Net-_D453-Pad1_ Net-_D453-Pad6_ GND VCC Net-_D477-Pad6_ APA102
D501 Net-_D501-Pad1_ Net-_D477-Pad1_ Net-_D477-Pad6_ GND VCC Net-_D501-Pad6_ APA102
D525 Net-_D525-Pad1_ Net-_D501-Pad1_ Net-_D501-Pad6_ GND VCC Net-_D525-Pad6_ APA102
D549 Net-_D549-Pad1_ Net-_D525-Pad1_ Net-_D525-Pad6_ GND VCC Net-_D549-Pad6_ APA102
D573 Net-_D22-Pad2_ Net-_D549-Pad1_ Net-_D549-Pad6_ GND VCC Net-_D22-Pad3_ APA102
D22 Net-_D22-Pad1_ Net-_D22-Pad2_ Net-_D22-Pad3_ GND VCC Net-_D22-Pad6_ APA102
D46 Net-_D46-Pad1_ Net-_D22-Pad1_ Net-_D22-Pad6_ GND VCC Net-_D46-Pad6_ APA102
D70 Net-_D70-Pad1_ Net-_D46-Pad1_ Net-_D46-Pad6_ GND VCC Net-_D70-Pad6_ APA102
D94 Net-_D118-Pad2_ Net-_D70-Pad1_ Net-_D70-Pad6_ GND VCC Net-_D118-Pad3_ APA102
D118 Net-_D118-Pad1_ Net-_D118-Pad2_ Net-_D118-Pad3_ GND VCC Net-_D118-Pad6_ APA102
D142 Net-_D142-Pad1_ Net-_D118-Pad1_ Net-_D118-Pad6_ GND VCC Net-_D142-Pad6_ APA102
D166 Net-_D166-Pad1_ Net-_D142-Pad1_ Net-_D142-Pad6_ GND VCC Net-_D166-Pad6_ APA102
D190 Net-_D190-Pad1_ Net-_D166-Pad1_ Net-_D166-Pad6_ GND VCC Net-_D190-Pad6_ APA102
D214 Net-_D214-Pad1_ Net-_D190-Pad1_ Net-_D190-Pad6_ GND VCC Net-_D214-Pad6_ APA102
D238 Net-_D238-Pad1_ Net-_D214-Pad1_ Net-_D214-Pad6_ GND VCC Net-_D238-Pad6_ APA102
D262 Net-_D262-Pad1_ Net-_D238-Pad1_ Net-_D238-Pad6_ GND VCC Net-_D262-Pad6_ APA102
D286 Net-_D286-Pad1_ Net-_D262-Pad1_ Net-_D262-Pad6_ GND VCC Net-_D286-Pad6_ APA102
D310 Net-_D310-Pad1_ Net-_D286-Pad1_ Net-_D286-Pad6_ GND VCC Net-_D310-Pad6_ APA102
D334 Net-_D334-Pad1_ Net-_D310-Pad1_ Net-_D310-Pad6_ GND VCC Net-_D334-Pad6_ APA102
D358 Net-_D358-Pad1_ Net-_D334-Pad1_ Net-_D334-Pad6_ GND VCC Net-_D358-Pad6_ APA102
D382 Net-_D382-Pad1_ Net-_D358-Pad1_ Net-_D358-Pad6_ GND VCC Net-_D382-Pad6_ APA102
D406 Net-_D406-Pad1_ Net-_D382-Pad1_ Net-_D382-Pad6_ GND VCC Net-_D406-Pad6_ APA102
D430 Net-_D430-Pad1_ Net-_D406-Pad1_ Net-_D406-Pad6_ GND VCC Net-_D430-Pad6_ APA102
D454 Net-_D454-Pad1_ Net-_D430-Pad1_ Net-_D430-Pad6_ GND VCC Net-_D454-Pad6_ APA102
D478 Net-_D478-Pad1_ Net-_D454-Pad1_ Net-_D454-Pad6_ GND VCC Net-_D478-Pad6_ APA102
D502 Net-_D502-Pad1_ Net-_D478-Pad1_ Net-_D478-Pad6_ GND VCC Net-_D502-Pad6_ APA102
D526 Net-_D526-Pad1_ Net-_D502-Pad1_ Net-_D502-Pad6_ GND VCC Net-_D526-Pad6_ APA102
D550 Net-_D550-Pad1_ Net-_D526-Pad1_ Net-_D526-Pad6_ GND VCC Net-_D550-Pad6_ APA102
D574 Net-_D23-Pad2_ Net-_D550-Pad1_ Net-_D550-Pad6_ GND VCC Net-_D23-Pad3_ APA102
D23 Net-_D23-Pad1_ Net-_D23-Pad2_ Net-_D23-Pad3_ GND VCC Net-_D23-Pad6_ APA102
D47 Net-_D47-Pad1_ Net-_D23-Pad1_ Net-_D23-Pad6_ GND VCC Net-_D47-Pad6_ APA102
D71 Net-_D71-Pad1_ Net-_D47-Pad1_ Net-_D47-Pad6_ GND VCC Net-_D71-Pad6_ APA102
D95 Net-_D119-Pad2_ Net-_D71-Pad1_ Net-_D71-Pad6_ GND VCC Net-_D119-Pad3_ APA102
D119 Net-_D119-Pad1_ Net-_D119-Pad2_ Net-_D119-Pad3_ GND VCC Net-_D119-Pad6_ APA102
D143 Net-_D143-Pad1_ Net-_D119-Pad1_ Net-_D119-Pad6_ GND VCC Net-_D143-Pad6_ APA102
D167 Net-_D167-Pad1_ Net-_D143-Pad1_ Net-_D143-Pad6_ GND VCC Net-_D167-Pad6_ APA102
D191 Net-_D191-Pad1_ Net-_D167-Pad1_ Net-_D167-Pad6_ GND VCC Net-_D191-Pad6_ APA102
D215 Net-_D215-Pad1_ Net-_D191-Pad1_ Net-_D191-Pad6_ GND VCC Net-_D215-Pad6_ APA102
D239 Net-_D239-Pad1_ Net-_D215-Pad1_ Net-_D215-Pad6_ GND VCC Net-_D239-Pad6_ APA102
D263 Net-_D263-Pad1_ Net-_D239-Pad1_ Net-_D239-Pad6_ GND VCC Net-_D263-Pad6_ APA102
D287 Net-_D287-Pad1_ Net-_D263-Pad1_ Net-_D263-Pad6_ GND VCC Net-_D287-Pad6_ APA102
D311 Net-_D311-Pad1_ Net-_D287-Pad1_ Net-_D287-Pad6_ GND VCC Net-_D311-Pad6_ APA102
D335 Net-_D335-Pad1_ Net-_D311-Pad1_ Net-_D311-Pad6_ GND VCC Net-_D335-Pad6_ APA102
D359 Net-_D359-Pad1_ Net-_D335-Pad1_ Net-_D335-Pad6_ GND VCC Net-_D359-Pad6_ APA102
D383 Net-_D383-Pad1_ Net-_D359-Pad1_ Net-_D359-Pad6_ GND VCC Net-_D383-Pad6_ APA102
D407 Net-_D407-Pad1_ Net-_D383-Pad1_ Net-_D383-Pad6_ GND VCC Net-_D407-Pad6_ APA102
D431 Net-_D431-Pad1_ Net-_D407-Pad1_ Net-_D407-Pad6_ GND VCC Net-_D431-Pad6_ APA102
D455 Net-_D455-Pad1_ Net-_D431-Pad1_ Net-_D431-Pad6_ GND VCC Net-_D455-Pad6_ APA102
D479 Net-_D479-Pad1_ Net-_D455-Pad1_ Net-_D455-Pad6_ GND VCC Net-_D479-Pad6_ APA102
D503 Net-_D503-Pad1_ Net-_D479-Pad1_ Net-_D479-Pad6_ GND VCC Net-_D503-Pad6_ APA102
D527 Net-_D527-Pad1_ Net-_D503-Pad1_ Net-_D503-Pad6_ GND VCC Net-_D527-Pad6_ APA102
D551 Net-_D551-Pad1_ Net-_D527-Pad1_ Net-_D527-Pad6_ GND VCC Net-_D551-Pad6_ APA102
D575 Net-_D24-Pad2_ Net-_D551-Pad1_ Net-_D551-Pad6_ GND VCC Net-_D24-Pad3_ APA102
D24 Net-_D24-Pad1_ Net-_D24-Pad2_ Net-_D24-Pad3_ GND VCC Net-_D24-Pad6_ APA102
D48 Net-_D48-Pad1_ Net-_D24-Pad1_ Net-_D24-Pad6_ GND VCC Net-_D48-Pad6_ APA102
D72 Net-_D72-Pad1_ Net-_D48-Pad1_ Net-_D48-Pad6_ GND VCC Net-_D72-Pad6_ APA102
D96 Net-_D120-Pad2_ Net-_D72-Pad1_ Net-_D72-Pad6_ GND VCC Net-_D120-Pad3_ APA102
D120 Net-_D120-Pad1_ Net-_D120-Pad2_ Net-_D120-Pad3_ GND VCC Net-_D120-Pad6_ APA102
D144 Net-_D144-Pad1_ Net-_D120-Pad1_ Net-_D120-Pad6_ GND VCC Net-_D144-Pad6_ APA102
D168 Net-_D168-Pad1_ Net-_D144-Pad1_ Net-_D144-Pad6_ GND VCC Net-_D168-Pad6_ APA102
D192 Net-_D192-Pad1_ Net-_D168-Pad1_ Net-_D168-Pad6_ GND VCC Net-_D192-Pad6_ APA102
D216 Net-_D216-Pad1_ Net-_D192-Pad1_ Net-_D192-Pad6_ GND VCC Net-_D216-Pad6_ APA102
D240 Net-_D240-Pad1_ Net-_D216-Pad1_ Net-_D216-Pad6_ GND VCC Net-_D240-Pad6_ APA102
D264 Net-_D264-Pad1_ Net-_D240-Pad1_ Net-_D240-Pad6_ GND VCC Net-_D264-Pad6_ APA102
D288 Net-_D288-Pad1_ Net-_D264-Pad1_ Net-_D264-Pad6_ GND VCC Net-_D288-Pad6_ APA102
D312 Net-_D312-Pad1_ Net-_D288-Pad1_ Net-_D288-Pad6_ GND VCC Net-_D312-Pad6_ APA102
D336 Net-_D336-Pad1_ Net-_D312-Pad1_ Net-_D312-Pad6_ GND VCC Net-_D336-Pad6_ APA102
D360 Net-_D360-Pad1_ Net-_D336-Pad1_ Net-_D336-Pad6_ GND VCC Net-_D360-Pad6_ APA102
D384 Net-_D384-Pad1_ Net-_D360-Pad1_ Net-_D360-Pad6_ GND VCC Net-_D384-Pad6_ APA102
D408 Net-_D408-Pad1_ Net-_D384-Pad1_ Net-_D384-Pad6_ GND VCC Net-_D408-Pad6_ APA102
D432 Net-_D432-Pad1_ Net-_D408-Pad1_ Net-_D408-Pad6_ GND VCC Net-_D432-Pad6_ APA102
D456 Net-_D456-Pad1_ Net-_D432-Pad1_ Net-_D432-Pad6_ GND VCC Net-_D456-Pad6_ APA102
D480 Net-_D480-Pad1_ Net-_D456-Pad1_ Net-_D456-Pad6_ GND VCC Net-_D480-Pad6_ APA102
D504 Net-_D504-Pad1_ Net-_D480-Pad1_ Net-_D480-Pad6_ GND VCC Net-_D504-Pad6_ APA102
D528 Net-_D528-Pad1_ Net-_D504-Pad1_ Net-_D504-Pad6_ GND VCC Net-_D528-Pad6_ APA102
D552 Net-_D552-Pad1_ Net-_D528-Pad1_ Net-_D528-Pad6_ GND VCC Net-_D552-Pad6_ APA102
D576 NC_29 Net-_D552-Pad1_ Net-_D552-Pad6_ GND VCC NC_30 APA102
C1 VCC GND 1uF
C4 VCC GND 1uF
C9 VCC GND 1uF
C12 VCC GND 1uF
C13 VCC GND 1uF
C14 VCC GND 1uF
C20 VCC GND 1uF
C22 VCC GND 1uF
LCKI1 LED-CKI LED-CKI
LSDI1 LED-SDI LED-SDI
LGND1 GND LED-GND
LVCC1 VCC LED-VCC
LEN1 LED-POWER-ENABLE LED-EN
Q1 LED-POWER-ENABLE +5V VCC IRLB8721PBF
R21 LED-POWER-ENABLE GND 10k
JLPWR1 VCC +5V LED-PWR
JLEN1 LED-POWER-ENABLE +3V3 LED-EN
R22 VCC Net-_PWR_DISPLAY1-Pad1_ 470R
PWR_DISPLAY1 Net-_PWR_DISPLAY1-Pad1_ GND LED
BATT-B-FUSE1 Net-_BATT-B-FUSE1-Pad1_ +BATT Polyfuse
BATT-A-FUSE1 Net-_BATT-A-FUSE1-Pad1_ Net-_BATT-A-FUSE1-Pad2_ Polyfuse
BATT-B1 Net-_BATT-B-FUSE1-Pad1_ Net-_BATT-A-FUSE1-Pad1_ 18650
BATT-A1 Net-_BATT-A-FUSE1-Pad2_ GND 18650
PWR_BATT1 Net-_PWR_BATT1-Pad1_ GND LED
R16 +BATT Net-_PWR_BATT1-Pad1_ 470R
IR_TX_F1 IR-TX-F Net-_IR_TX_F1-Pad2_ IR204A
IR_RX_L2 IR-TX-L Net-_IR_RX_L1-Pad2_ IR204A
IR_RX_R2 IR-TX-R Net-_IR_RX_R1-Pad2_ IR204A
R1 GND Net-_IR_TX_F1-Pad2_ 100R
R3 GND Net-_IR_RX_L1-Pad2_ 100R
R2 GND Net-_IR_RX_R1-Pad2_ 100R
R23 Net-_C3-Pad1_ +3V3 100
R24 Net-_C5-Pad1_ +3V3 100
R25 Net-_C6-Pad1_ +3V3 100
IR-F1 GND Net-_C3-Pad1_ IR-RX-F GND TSOP77
IR-L1 GND Net-_C5-Pad1_ IR-RX-L GND TSOP77
IR-R1 GND Net-_C6-Pad1_ IR-RX-R GND TSOP77
C6 Net-_C6-Pad1_ GND 0.1uF
C5 Net-_C5-Pad1_ GND 0.1uF
C3 Net-_C3-Pad1_ GND 0.1uF
IR_RX_L1 IR-TX-L Net-_IR_RX_L1-Pad2_ IR204A
IR_TX_F2 IR-TX-F Net-_IR_TX_F1-Pad2_ IR204A
IR_RX_R1 IR-TX-R Net-_IR_RX_R1-Pad2_ IR204A
.end
