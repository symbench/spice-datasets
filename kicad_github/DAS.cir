.title KiCad schematic
U6 /RST /AN0 /AN1 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 +5V GND Net-_C6-Pad1_ Net-_C5-Pad1_ /RS /R-W /E /SCK /DB0 /DB1 /DB2 /DB3 /MOSI /MISO /TX_L /RX_L /DB4 /DB5 /DB6 /DB7 GND +5V NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 PIC18F452-IP
R9 +5V Net-_R10-Pad2_ 10k
SW1 GND Net-_R10-Pad2_ SW_Push
Y1 Net-_C5-Pad1_ Net-_C6-Pad1_ 8MHz
C5 Net-_C5-Pad1_ GND 22pF
C6 Net-_C6-Pad1_ GND 22pF
R10 /RST Net-_R10-Pad2_ 270
C7 +5V GND 220uF
C8 +5V GND .1uF
C9 +5V GND 1uF
U4 NC_16 Net-_R4-Pad1_ Net-_U1-Pad2_ -12V NC_17 /AN0 +12V NC_18 OP07
R4 Net-_R4-Pad1_ GND 1k
R1 Net-_R1-Pad1_ GND 6.67K
R2 Net-_R2-Pad1_ Net-_J2-Pad2_ 20K
U2 NC_19 Net-_R2-Pad1_ Net-_R1-Pad1_ -12V NC_20 Net-_R3-Pad1_ +12V NC_21 OP07
R3 Net-_R3-Pad1_ Net-_R2-Pad1_ 10k
R5 Net-_R5-Pad1_ Net-_R3-Pad1_ 10K
U3 +12V GND +5V L7805
C1 +12V GND 1500uF
C3 +5V GND .1uF
C2 +12V GND .33uF
C4 +5V GND 440uF
U5 NC_22 Net-_R5-Pad1_ Net-_R6-Pad1_ -12V NC_23 /AN1 +12V NC_24 OP07
R6 Net-_R6-Pad1_ GND 5K
RV1 GND Net-_DS1-Pad3_ +5V R_POT
R11 +5V Net-_DS1-Pad15_ 1k
R8 /AN1 Net-_R5-Pad1_ 10k
R7 /AN0 Net-_R4-Pad1_ 2.33k
U1 +5V Net-_U1-Pad2_ GND LM35-LP
J2 +5V Net-_J2-Pad2_ GND Pressure Sensor
J1 -12V GND +12V Screw_Terminal_01x03
U7 Net-_C10-Pad1_ Net-_C12-Pad2_ Net-_C10-Pad2_ Net-_C11-Pad1_ Net-_C11-Pad2_ Net-_C13-Pad2_ NC_25 NC_26 NC_27 NC_28 /TX_L /RX_L /RX_H /TX_H GND +5V MAX232
DS1 GND +5V Net-_DS1-Pad3_ /RS /R-W /E /DB0 /DB1 /DB2 /DB3 /DB4 /DB5 /DB6 /DB7 Net-_DS1-Pad15_ GND WC1602A
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 1uF
C11 Net-_C11-Pad1_ Net-_C11-Pad2_ 1uF
C12 GND Net-_C12-Pad2_ 1uF
C13 GND Net-_C13-Pad2_ 1uF
J4 GND NC_29 /RX_H /TX_H NC_30 GND NC_31 NC_32 NC_33 NC_34 DB9_Female_MountingHoles
J3 /MISO +5V /SCK /MOSI /RST GND AVR-ISP-6
.end
