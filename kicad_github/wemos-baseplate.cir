.title KiCad schematic
IU1 /RST /SVP /IO26 /IO18 /IO19 /IO23 /IO05 /3.3V /TCK /SD3 /SD0 /TD0 /5V /GND /IO16 /IO17 /SDA /SCL /RXD /TXD /GND /NC1 /SVN /IO35 /IO33 /IO34 /TMS /NC2 /SD2 /CMD /CLK /SD1 /IO02 /IO00 /IO04 /TDI /IO32 /IO25 /IO27 /GND ESP32-MINI-32
IU2 /RST /SVP /IO26 /IO18 /IO19 /IO23 /IO05 /3.3V /TCK /SD3 /SD0 /TD0 /5V /GND /IO16 /IO17 /SDA /SCL /RXD /TXD /GND /NC1 /SVN /IO35 /IO33 /IO34 /TMS /NC2 /SD2 /CMD /CLK /SD1 /IO02 /IO00 /IO04 /TDI /IO32 /IO25 /IO27 /GND ESP32-MINI-32
IU3 /RST /SVP /IO26 /IO18 /IO19 /IO23 /IO05 /3.3V /TCK /SD3 /SD0 /TD0 /5V /GND /IO16 /IO17 /SDA /SCL /RXD /TXD /GND /NC1 /SVN /IO35 /IO33 /IO34 /TMS /NC2 /SD2 /CMD /CLK /SD1 /IO02 /IO00 /IO04 /TDI /IO32 /IO25 /IO27 /GND ESP32-MINI-32
J3 /SCL /SDA /3.3V /GND Conn_01x04
J5 /SCL /SDA /3.3V /GND Conn_01x04
J6 /SCL /SDA /3.3V /GND Conn_01x04
J4 /SCL /SDA /3.3V /GND Conn_01x04
J1 /IO02 /NC2 /IO00 /TMS /IO04 /IO34 /TDI /IO33 /IO32 /IO35 /IO25 /SVN /IO27 /NC1 /TD0 /TCK /5V /3.3V /GND /IO05 /IO16 /IO23 /IO17 /IO19 /SDA /IO18 /SCL /IO26 /RXD /SVP /TXD /RST Conn_02x16_Odd_Even
J2 /IO02 /NC2 /IO00 /TMS /IO04 /IO34 /TDI /IO33 /IO32 /IO35 /IO25 /SVN /IO27 /NC1 /TD0 /TCK /5V /3.3V /GND /IO05 /IO16 /IO23 /IO17 /IO19 /SDA /IO18 /SCL /IO26 /RXD /SVP /TXD /RST Conn_02x16_Odd_Even
J7 /IO33 /IO32 /3.3V /GND Conn_01x04
J9 /IO26 /IO25 /3.3V /GND Conn_01x04
J11 /TMS /IO27 /3.3V /GND Conn_01x04
J13 /TD0 /IO04 /3.3V /GND Conn_01x04
J15 /IO34 /IO35 /3.3V /GND Conn_01x04
J8 /SVP /SVN /3.3V /GND Conn_01x04
J10 /IO18 /IO19 /3.3V /GND Conn_01x04
J12 /IO16 /IO17 /3.3V /GND Conn_01x04
J14 /RXD /TXD /3.3V /GND Conn_01x04
.end
