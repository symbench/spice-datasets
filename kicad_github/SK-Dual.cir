.title KiCad schematic
C57 NC_01 Net-_C57-Pad2_ C
C59 NC_02 Net-_C57-Pad2_ C
C58 Net-_C58-Pad1_ NC_03 C
C60 Net-_C58-Pad1_ NC_04 C
J24 Net-_C57-Pad2_ NC_05 Net-_J24-Pad3_ Net-_J24-Pad4_ NC_06 Net-_C58-Pad1_ InConnector
J25 Net-_C61-Pad2_ NC_07 Net-_J25-Pad3_ Net-_J25-Pad4_ NC_08 Net-_C62-Pad1_ OutConnector
U14 NC_09 Net-_R161-Pad1_ Net-_R156-Pad2_ NC_10 NC_11 Net-_J25-Pad3_ NC_12 NC_13 OPA333xxD
R161 Net-_R161-Pad1_ Net-_J25-Pad3_ R
R159 NC_14 Net-_R156-Pad2_ R
R155 Net-_R153-Pad2_ Net-_J25-Pad3_ R
R156 Net-_R153-Pad2_ Net-_R156-Pad2_ R
R153 Net-_J24-Pad3_ Net-_R153-Pad2_ R
R162 NC_15 Net-_R161-Pad1_ R
U15 NC_16 Net-_R163-Pad1_ Net-_R158-Pad2_ NC_17 NC_18 Net-_J25-Pad4_ NC_19 NC_20 OPA333xxD
R163 Net-_R163-Pad1_ Net-_J25-Pad4_ R
R160 NC_21 Net-_R158-Pad2_ R
R157 Net-_R154-Pad2_ Net-_J25-Pad4_ R
R158 Net-_R154-Pad2_ Net-_R158-Pad2_ R
R154 Net-_J24-Pad4_ Net-_R154-Pad2_ R
R164 NC_22 Net-_R163-Pad1_ R
C61 NC_23 Net-_C61-Pad2_ C
C63 NC_24 Net-_C61-Pad2_ C
C62 Net-_C62-Pad1_ NC_25 C
C64 Net-_C62-Pad1_ NC_26 C
C65 NC_27 Net-_C65-Pad2_ C
C67 NC_28 Net-_C65-Pad2_ C
C66 Net-_C66-Pad1_ NC_29 C
C68 Net-_C66-Pad1_ NC_30 C
J26 Net-_C65-Pad2_ NC_31 Net-_J26-Pad3_ Net-_J26-Pad4_ NC_32 Net-_C66-Pad1_ InConnector
J27 Net-_C69-Pad2_ NC_33 Net-_J27-Pad3_ Net-_J27-Pad4_ NC_34 Net-_C70-Pad1_ OutConnector
R171 NC_35 Net-_R168-Pad2_ R
R167 Net-_R165-Pad2_ Net-_R167-Pad2_ R
R168 Net-_R165-Pad2_ Net-_R168-Pad2_ R
R165 Net-_J26-Pad3_ Net-_R165-Pad2_ R
U16 Net-_J27-Pad3_ Net-_R185-Pad1_ Net-_R180-Pad2_ NC_36 Net-_R168-Pad2_ Net-_R173-Pad1_ Net-_R167-Pad2_ NC_37 ADA4807-2ARM
R183 NC_38 Net-_R180-Pad2_ R
R179 Net-_R177-Pad2_ Net-_J27-Pad3_ R
R180 Net-_R177-Pad2_ Net-_R180-Pad2_ R
R177 Net-_R167-Pad2_ Net-_R177-Pad2_ R
R173 Net-_R173-Pad1_ Net-_R167-Pad2_ R
R174 NC_39 Net-_R173-Pad1_ R
R185 Net-_R185-Pad1_ Net-_J27-Pad3_ R
R186 NC_40 Net-_R185-Pad1_ R
C69 NC_41 Net-_C69-Pad2_ C
C71 NC_42 Net-_C69-Pad2_ C
C70 Net-_C70-Pad1_ NC_43 C
C72 Net-_C70-Pad1_ NC_44 C
R172 NC_45 Net-_R170-Pad2_ R
R169 Net-_R166-Pad2_ Net-_R169-Pad2_ R
R170 Net-_R166-Pad2_ Net-_R170-Pad2_ R
R166 Net-_J26-Pad4_ Net-_R166-Pad2_ R
U17 Net-_J27-Pad4_ Net-_R187-Pad1_ Net-_R182-Pad2_ NC_46 Net-_R170-Pad2_ Net-_R175-Pad1_ Net-_R169-Pad2_ NC_47 ADA4807-2ARM
R184 NC_48 Net-_R182-Pad2_ R
R181 Net-_R178-Pad2_ Net-_J27-Pad4_ R
R182 Net-_R178-Pad2_ Net-_R182-Pad2_ R
R178 Net-_R169-Pad2_ Net-_R178-Pad2_ R
R175 Net-_R175-Pad1_ Net-_R169-Pad2_ R
R176 NC_49 Net-_R175-Pad1_ R
R187 Net-_R187-Pad1_ Net-_J27-Pad4_ R
R188 NC_50 Net-_R187-Pad1_ R
.end
