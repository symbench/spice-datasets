.title KiCad schematic
U2 /col2 VCC D- D+ GND Net-_C4-Pad1_ VCC /col8 /SCK /MOSI /MISO /col9 /~RES~ VCC GND XTAL2 XTAL1 /row0 /row1 /row2 /row3 /row4 GND VCC /col6 /col13 /col12 /col11 /col10 /col5 /col4 /col3 Net-_R4-Pad1_ VCC GND /PF7 /PF6 /PF5 /PF4 /col1 /col0 NC_01 GND VCC ATmega32U4-AU
J1 VCC Net-_J1-Pad2_ Net-_J1-Pad3_ NC_02 GND GND USB_B_Micro
U1 NC_03 GND NC_04 Net-_J1-Pad2_ VCC Net-_J1-Pad3_ USBLC6-2SC6
R1 D+ Net-_J1-Pad3_ 22
R2 D- Net-_J1-Pad2_ 22
C4 Net-_C4-Pad1_ GND 1uF (±10%)
Y1 XTAL1 GND XTAL2 GND Crystal_GND24
C1 GND XTAL1 22pF
C2 XTAL2 GND 22pF
C3 VCC GND 10uF
SWR1 GND /~RES~ SW_Push
R3 VCC /~RES~ 10K
C5 VCC GND 1uF
C6 VCC GND 0.1uF
C8 VCC GND 0.1uF
C7 VCC GND 0.1uF
C9 VCC GND 0.1uF
R4 Net-_R4-Pad1_ GND 10K
J8 /PF4 PF4
J9 /PF5 PF5
J10 /PF6 PF6
J11 /PF7 PF7
J2 /MISO MISO
J3 VCC VCC
J4 /SCK SCK
J5 /MOSI MOSI
J6 /~RES~ RES
J7 GND GND
J13 Net-_J1-Pad3_ D+
J14 Net-_J1-Pad2_ D-
J12 VCC VCC
J15 GND GND
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
H5 MountingHole
H6 MountingHole
H7 MountingHole
H8 MountingHole
SW1 /col0 Net-_D1-Pad2_ SW_Push
D1 /row0 Net-_D1-Pad2_ D
SW6 /col1 Net-_D6-Pad2_ SW_Push
SW2 /col0 Net-_D2-Pad2_ SW_Push
D2 /row1 Net-_D2-Pad2_ D
D6 /row0 Net-_D6-Pad2_ D
SW7 /col1 Net-_D7-Pad2_ SW_Push
D7 /row1 Net-_D7-Pad2_ D
SW3 /col0 Net-_D3-Pad2_ SW_Push
D3 /row2 Net-_D3-Pad2_ D
SW4 /col0 Net-_D4-Pad2_ SW_Push
SW5 /col0 Net-_D5-Pad2_ SW_Push
D4 /row3 Net-_D4-Pad2_ D
D5 /row4 Net-_D5-Pad2_ D
SW8 /col1 Net-_D8-Pad2_ SW_Push
SW9 /col1 Net-_D9-Pad2_ SW_Push
D8 /row2 Net-_D8-Pad2_ D
D9 /row3 Net-_D9-Pad2_ D
SW10 /col2 Net-_D10-Pad2_ SW_Push
D10 /row0 Net-_D10-Pad2_ D
SW11 /col2 Net-_D11-Pad2_ SW_Push
D11 /row1 Net-_D11-Pad2_ D
SW12 /col2 Net-_D12-Pad2_ SW_Push
SW13 /col2 Net-_D13-Pad2_ SW_Push
SW14 /col2 Net-_D14-Pad2_ SW_Push
D12 /row2 Net-_D12-Pad2_ D
D13 /row3 Net-_D13-Pad2_ D
D14 /row4 Net-_D14-Pad2_ D
SW15 /col3 Net-_D15-Pad2_ SW_Push
D15 /row0 Net-_D15-Pad2_ D
SW16 /col3 Net-_D16-Pad2_ SW_Push
D16 /row1 Net-_D16-Pad2_ D
SW17 /col3 Net-_D17-Pad2_ SW_Push
SW18 /col3 Net-_D18-Pad2_ SW_Push
D17 /row2 Net-_D17-Pad2_ D
D18 /row3 Net-_D18-Pad2_ D
SW19 /col4 Net-_D19-Pad2_ SW_Push
D19 /row0 Net-_D19-Pad2_ D
SW20 /col4 Net-_D20-Pad2_ SW_Push
D20 /row1 Net-_D20-Pad2_ D
SW21 /col4 Net-_D21-Pad2_ SW_Push
SW22 /col4 Net-_D22-Pad2_ SW_Push
SW23 /col4 Net-_D23-Pad2_ SW_Push
D21 /row2 Net-_D21-Pad2_ D
D22 /row3 Net-_D22-Pad2_ D
D23 /row4 Net-_D23-Pad2_ D
SW24 /col5 Net-_D24-Pad2_ SW_Push
D24 /row0 Net-_D24-Pad2_ D
SW25 /col5 Net-_D25-Pad2_ SW_Push
D25 /row1 Net-_D25-Pad2_ D
SW26 /col5 Net-_D26-Pad2_ SW_Push
SW27 /col5 Net-_D27-Pad2_ SW_Push
SW28 /col5 Net-_D28-Pad2_ SW_Push
D26 /row2 Net-_D26-Pad2_ D
D27 /row3 Net-_D27-Pad2_ D
D28 /row4 Net-_D28-Pad2_ D
SW29 /col6 Net-_D29-Pad2_ SW_Push
D29 /row0 Net-_D29-Pad2_ D
SW30 /col6 Net-_D30-Pad2_ SW_Push
D30 /row1 Net-_D30-Pad2_ D
SW31 /col6 Net-_D31-Pad2_ SW_Push
SW32 /col6 Net-_D32-Pad2_ SW_Push
D31 /row2 Net-_D31-Pad2_ D
D32 /row3 Net-_D32-Pad2_ D
SW33 /SCK Net-_D33-Pad2_ SW_Push
D33 /row0 Net-_D33-Pad2_ D
SW34 /SCK Net-_D34-Pad2_ SW_Push
D34 /row1 Net-_D34-Pad2_ D
SW35 /SCK Net-_D35-Pad2_ SW_Push
SW36 /SCK Net-_D36-Pad2_ SW_Push
SW37 /SCK Net-_D37-Pad2_ SW_Push
D35 /row2 Net-_D35-Pad2_ D
D36 /row3 Net-_D36-Pad2_ D
D37 /row4 Net-_D37-Pad2_ D
SW38 /col8 Net-_D38-Pad2_ SW_Push
D38 /row0 Net-_D38-Pad2_ D
SW39 /col8 Net-_D39-Pad2_ SW_Push
D39 /row1 Net-_D39-Pad2_ D
SW40 /col8 Net-_D40-Pad2_ SW_Push
SW41 /col8 Net-_D41-Pad2_ SW_Push
D40 /row2 Net-_D40-Pad2_ D
D41 /row3 Net-_D41-Pad2_ D
SW42 /col9 Net-_D42-Pad2_ SW_Push
D42 /row0 Net-_D42-Pad2_ D
SW43 /col9 Net-_D43-Pad2_ SW_Push
D43 /row1 Net-_D43-Pad2_ D
SW44 /col9 Net-_D44-Pad2_ SW_Push
SW45 /col9 Net-_D45-Pad2_ SW_Push
SW46 /col9 Net-_D46-Pad2_ SW_Push
D44 /row2 Net-_D44-Pad2_ D
D45 /row3 Net-_D45-Pad2_ D
D46 /row4 Net-_D46-Pad2_ D
SW47 /col10 Net-_D47-Pad2_ SW_Push
D47 /row0 Net-_D47-Pad2_ D
SW48 /col10 Net-_D48-Pad2_ SW_Push
D48 /row1 Net-_D48-Pad2_ D
SW49 /col10 Net-_D49-Pad2_ SW_Push
SW50 /col10 Net-_D50-Pad2_ SW_Push
D49 /row2 Net-_D49-Pad2_ D
D50 /row3 Net-_D50-Pad2_ D
SW51 /col11 Net-_D51-Pad2_ SW_Push
D51 /row0 Net-_D51-Pad2_ D
SW52 /col11 Net-_D52-Pad2_ SW_Push
D52 /row1 Net-_D52-Pad2_ D
SW53 /col11 Net-_D53-Pad2_ SW_Push
SW54 /col11 Net-_D54-Pad2_ SW_Push
D53 /row2 Net-_D53-Pad2_ D
D54 /row3 Net-_D54-Pad2_ D
SW55 /col12 Net-_D55-Pad2_ SW_Push
D55 /row0 Net-_D55-Pad2_ D
SW56 /col12 Net-_D56-Pad2_ SW_Push
D56 /row1 Net-_D56-Pad2_ D
SW57 /col12 Net-_D57-Pad2_ SW_Push
SW58 /col12 Net-_D58-Pad2_ SW_Push
D57 /row2 Net-_D57-Pad2_ D
D58 /row4 Net-_D58-Pad2_ D
SW59 /col13 Net-_D59-Pad2_ SW_Push
D59 /row0 Net-_D59-Pad2_ D
SW60 /col13 Net-_D60-Pad2_ SW_Push
D60 /row1 Net-_D60-Pad2_ D
SW61 /col13 Net-_D61-Pad2_ SW_Push
SW62 /col13 Net-_D62-Pad2_ SW_Push
D61 /row3 Net-_D61-Pad2_ D
D62 /row4 Net-_D62-Pad2_ D
SW63 /MISO Net-_D63-Pad2_ SW_Push
D63 /row0 Net-_D63-Pad2_ D
SW64 /MISO Net-_D64-Pad2_ SW_Push
D64 /row1 Net-_D64-Pad2_ D
SW65 /MISO Net-_D65-Pad2_ SW_Push
SW66 /MISO Net-_D66-Pad2_ SW_Push
SW67 /MISO Net-_D67-Pad2_ SW_Push
D65 /row2 Net-_D65-Pad2_ D
D66 /row3 Net-_D66-Pad2_ D
D67 /row4 Net-_D67-Pad2_ D
.
.end
