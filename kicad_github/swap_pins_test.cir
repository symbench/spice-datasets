.title KiCad schematic
U101 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 +5V NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 GND +5V NC_30 RB1 RB2 RB3 RB4 NC_31 NC_32 NC_33 PIC18F452-IP
R101 Net-_C101-Pad1_ RB1 R
R102 Net-_C101-Pad1_ RB2 R
R103 Net-_C101-Pad1_ RB3 R
R104 Net-_C101-Pad1_ RB4 R
C101 Net-_C101-Pad1_ GND C
U1 A2 NC_34 A6 NC_35 NC_36 A1 NC_37 A4 A5 LM324
R5 Net-_C2-Pad1_ A1 R
R6 Net-_C2-Pad1_ A2 R
C2 Net-_C2-Pad1_ GND C
U3 A2 NC_38 A6 NC_39 A4 A5 LM324
U201 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 +5V GND NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 /level_1/RD1 /level_1/RD2 /level_1/RD3 NC_57 NC_58 NC_59 NC_60 /level_1/RD4 NC_61 NC_62 NC_63 GND +5V NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 PIC18F452-IP
R201 Net-_C201-Pad1_ /level_1/RD1 R
R202 Net-_C201-Pad1_ /level_1/RD2 R
R203 Net-_C201-Pad1_ /level_1/RD3 R
R204 Net-_C201-Pad1_ /level_1/RD4 R
C201 Net-_C201-Pad1_ GND C
R1 Net-_C1-Pad1_ /level_1/Lavel_2/RC1 R
R2 Net-_C1-Pad1_ /level_1/Lavel_2/RC2 R
R3 Net-_C1-Pad1_ /level_1/Lavel_2/RC3 R
R4 Net-_C1-Pad1_ /level_1/Lavel_2/RC4 R
C1 Net-_C1-Pad1_ GND C
U301 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 +5V GND NC_82 NC_83 NC_84 /level_1/Lavel_2/RC1 /level_1/Lavel_2/RC2 /level_1/Lavel_2/RC3 NC_85 NC_86 NC_87 NC_88 /level_1/Lavel_2/RC4 NC_89 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 GND +5V NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 PIC18F452-IP
U2 NC_104 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 NC_111 NC_112 NC_113 +5V GND NC_114 NC_115 NC_116 NC_117 NC_118 NC_119 NC_120 NC_121 NC_122 NC_123 NC_124 NC_125 NC_126 NC_127 NC_128 NC_129 NC_130 NC_131 GND +5V NC_132 NC_133 NC_134 NC_135 NC_136 NC_137 NC_138 NC_139 PIC18F452-IP
.end
