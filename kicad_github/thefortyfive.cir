.title KiCad schematic
J1 Net-_J1-Pad1_ NC_01 NC_02 GND Row2 Row4 Row6 Row5 Row3 Row1 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 Conn_01x16_Female
J2 NC_09 NC_10 NC_11 Row8 Col1 Col2 Col3 Col4 Col5 Col6 Col7 Row7 Conn_01x12_Female
D1 Row1 Net-_D1-Pad2_ D_SOD-123
MX1,2 Col2 Net-_D5-Pad2_ MX-NoLED
D5 Row1 Net-_D5-Pad2_ D_SOD-123
MX1,3 Col3 Net-_D9-Pad2_ MX-NoLED
D9 Row1 Net-_D9-Pad2_ D_SOD-123
D13 Row1 Net-_D13-Pad2_ D_SOD-123
MX3,1 Col1 Net-_D2-Pad2_ MX-NoLED
D2 Row3 Net-_D2-Pad2_ D_SOD-123
MX3,2 Col2 Net-_D6-Pad2_ MX-NoLED
D6 Row3 Net-_D6-Pad2_ D_SOD-123
MX3,3 Col3 Net-_D10-Pad2_ MX-NoLED
D10 Row3 Net-_D10-Pad2_ D_SOD-123
D14 Row3 Net-_D14-Pad2_ D_SOD-123
MX5,1 Col1 Net-_D3-Pad2_ MX-NoLED
D3 Row5 Net-_D3-Pad2_ D_SOD-123
MX5,2 Col2 Net-_D7-Pad2_ MX-NoLED
D7 Row5 Net-_D7-Pad2_ D_SOD-123
MX5,3 Col3 Net-_D11-Pad2_ MX-NoLED
D11 Row5 Net-_D11-Pad2_ D_SOD-123
D15 Row5 Net-_D15-Pad2_ D_SOD-123
MX7,2 Col2 Net-_D8-Pad2_ MX-NoLED
D8 Row7 Net-_D8-Pad2_ D_SOD-123
MX7,3 Col3 Net-_D12-Pad2_ MX-NoLED
D12 Row7 Net-_D12-Pad2_ D_SOD-123
D16 Row7 Net-_D16-Pad2_ D_SOD-123
MX1,1 Col1 Net-_D1-Pad2_ MX-NoLED
D31 Row8 Net-_D31-Pad2_ D_SOD-123
MX8,1 Col1 Net-_D31-Pad2_ MX-NoLED
D27 Row7 Net-_D27-Pad2_ D_SOD-123
MX7,7 Col7 Net-_D27-Pad2_ MX-NoLED
D23 Row7 Net-_D23-Pad2_ D_SOD-123
MX7,6 Col6 Net-_D23-Pad2_ MX-NoLED
MX7,4 Col4 Net-_D16-Pad2_ MX-NoLED
D34 Row6 Net-_D34-Pad2_ D_SOD-123
MX6,2 Col2 Net-_D34-Pad2_ MX-NoLED
D30 Row6 Net-_D30-Pad2_ D_SOD-123
MX6,1 Col1 Net-_D30-Pad2_ MX-NoLED
D26 Row5 Net-_D26-Pad2_ D_SOD-123
MX5,7 Col7 Net-_D26-Pad2_ MX-NoLED
D22 Row5 Net-_D22-Pad2_ D_SOD-123
MX5,6 Col6 Net-_D22-Pad2_ MX-NoLED
D19 Row5 Net-_D19-Pad2_ D_SOD-123
MX5,5 Col5 Net-_D19-Pad2_ MX-NoLED
MX5,4 Col4 Net-_D15-Pad2_ MX-NoLED
D33 Row4 Net-_D33-Pad2_ D_SOD-123
MX4,2 Col2 Net-_D33-Pad2_ MX-NoLED
D29 Row4 Net-_D29-Pad2_ D_SOD-123
MX4,1 Col1 Net-_D29-Pad2_ MX-NoLED
D25 Row3 Net-_D25-Pad2_ D_SOD-123
MX3,7 Col7 Net-_D25-Pad2_ MX-NoLED
D21 Row3 Net-_D21-Pad2_ D_SOD-123
MX3,6 Col6 Net-_D21-Pad2_ MX-NoLED
D18 Row3 Net-_D18-Pad2_ D_SOD-123
MX3,5 Col5 Net-_D18-Pad2_ MX-NoLED
MX3,4 Col4 Net-_D14-Pad2_ MX-NoLED
D32 Row2 Net-_D32-Pad2_ D_SOD-123
MX2,2 Col2 Net-_D32-Pad2_ MX-NoLED
D28 Row2 Net-_D28-Pad2_ D_SOD-123
MX2,1 Col1 Net-_D28-Pad2_ MX-NoLED
D24 Row1 Net-_D24-Pad2_ D_SOD-123
D20 Row1 Net-_D20-Pad2_ D_SOD-123
MX1,6 Col6 Net-_D20-Pad2_ MX-NoLED
D17 Row1 Net-_D17-Pad2_ D_SOD-123
MX1,5 Col5 Net-_D17-Pad2_ MX-NoLED
MX1,4 Col4 Net-_D13-Pad2_ MX-NoLED
MX2,3 Col3 Net-_D35-Pad2_ MX-NoLED
D35 Row2 Net-_D35-Pad2_ D_SOD-123
D39 Row2 Net-_D39-Pad2_ D_SOD-123
D43 Row2 Net-_D43-Pad2_ D_SOD-123
MX4,3 Col3 Net-_D36-Pad2_ MX-NoLED
D36 Row4 Net-_D36-Pad2_ D_SOD-123
MX4,4 Col4 Net-_D40-Pad2_ MX-NoLED
D40 Row4 Net-_D40-Pad2_ D_SOD-123
MX4,6 Col6 Net-_D47-Pad2_ MX-NoLED
D47 Row4 Net-_D47-Pad2_ D_SOD-123
MX6,3 Col3 Net-_D37-Pad2_ MX-NoLED
D37 Row6 Net-_D37-Pad2_ D_SOD-123
MX6,4 Col4 Net-_D41-Pad2_ MX-NoLED
D41 Row6 Net-_D41-Pad2_ D_SOD-123
MX6,6 Col6 Net-_D48-Pad2_ MX-NoLED
D48 Row6 Net-_D48-Pad2_ D_SOD-123
MX8,3 Col3 Net-_D38-Pad2_ MX-NoLED
D38 Row8 Net-_D38-Pad2_ D_SOD-123
MX8,4 Col4 Net-_D42-Pad2_ MX-NoLED
D42 Row8 Net-_D42-Pad2_ D_SOD-123
MX8,5 Col5 Net-_D45-Pad2_ MX-NoLED
D45 Row8 Net-_D45-Pad2_ D_SOD-123
MX2,5 Col5 Net-_D43-Pad2_ MX-NoLED
D46 Row2 Net-_D46-Pad2_ D_SOD-123
MX2,6 Col6 Net-_D46-Pad2_ MX-NoLED
MX2,4 Col4 Net-_D39-Pad2_ MX-NoLED
MX1,7 Col7 Net-_D24-Pad2_ MX-NoLED
SW1 GND Net-_J1-Pad1_ SW_Push
.end
