.title KiCad schematic
U2 /EN_Y0 /LOW_Y0 /OUT_Y0 GND GND Net-_R1-Pad1_ /HI_Y0 +5V /EN_X0 /HI_X0 Net-_R5-Pad2_ GND GND /OUT_X0 /LOW_X0 /LOGIC_PWR SN754410
U1 GND /+9V +5V 7805
R1 Net-_R1-Pad1_ /IN_Y0 10R
R5 /IN_X0 Net-_R5-Pad2_ 10R
P1 /HI_Y7 /HI_Y6 /HI_Y5 /HI_Y4 /HI_Y3 /HI_Y2 /HI_Y1 /HI_Y0 /LOW_Y7 /LOW_Y6 /LOW_Y5 /LOW_Y4 /LOW_Y3 /LOW_Y2 /LOW_Y1 /LOW_Y0 CONN_01X16
P2 /HI_X7 /HI_X6 /HI_X5 /HI_X4 /HI_X3 /HI_X2 /HI_X1 /HI_X0 /LOW_X7 /LOW_X6 /LOW_X5 /LOW_X4 /LOW_X3 /LOW_X2 /LOW_X1 /LOW_X0 CONN_01X16
P3 GND /+9V /LOGIC_PWR +5V CONN_01X04
P9 /IN_Y0 /IN_Y1 /IN_Y2 /IN_Y3 /IN_Y4 /IN_Y5 /IN_Y6 /IN_Y7 /OUT_Y0 /OUT_Y1 /OUT_Y2 /OUT_Y3 /OUT_Y4 /OUT_Y5 /OUT_Y6 /OUT_Y7 CONN_01X16
P10 /IN_X0 /IN_X1 /IN_X2 /IN_X3 /IN_X4 /IN_X5 /IN_X6 /IN_X7 /OUT_X0 /OUT_X1 /OUT_X2 /OUT_X3 /OUT_X4 /OUT_X5 /OUT_X6 /OUT_X7 CONN_01X16
C1 /+9V GND 10U
C4 +5V GND 10U
C2 /+9V GND 100N
C3 +5V GND 100N
P4 /+9V GND +5V CONN_01X03
P5 /EN_Y7 /EN_Y6 /EN_Y5 /EN_Y4 /EN_Y3 /EN_Y2 /EN_Y1 /EN_Y0 /EN_X7 /EN_X6 /EN_X5 /EN_X4 /EN_X3 /EN_X2 /EN_X1 /EN_X0 CONN_01X16
U6 /EN_Y1 /LOW_Y1 /OUT_Y1 GND GND Net-_R9-Pad1_ /HI_Y1 +5V /EN_X1 /HI_X1 Net-_R13-Pad2_ GND GND /OUT_X1 /LOW_X1 /LOGIC_PWR SN754410
R9 Net-_R9-Pad1_ /IN_Y1 10R
R13 /IN_X1 Net-_R13-Pad2_ 10R
U4 /EN_Y2 /LOW_Y2 /OUT_Y2 GND GND Net-_R3-Pad1_ /HI_Y2 +5V /EN_X2 /HI_X2 Net-_R7-Pad2_ GND GND /OUT_X2 /LOW_X2 /LOGIC_PWR SN754410
R3 Net-_R3-Pad1_ /IN_Y2 10R
R7 /IN_X2 Net-_R7-Pad2_ 10R
U8 /EN_Y3 /LOW_Y3 /OUT_Y3 GND GND Net-_R11-Pad1_ /HI_Y3 +5V /EN_X3 /HI_X3 Net-_R15-Pad2_ GND GND /OUT_X3 /LOW_X3 /LOGIC_PWR SN754410
R11 Net-_R11-Pad1_ /IN_Y3 10R
R15 /IN_X3 Net-_R15-Pad2_ 10R
U3 /EN_Y4 /LOW_Y4 /OUT_Y4 GND GND Net-_R2-Pad1_ /HI_Y4 +5V /EN_X4 /HI_X4 Net-_R6-Pad2_ GND GND /OUT_X4 /LOW_X4 /LOGIC_PWR SN754410
R2 Net-_R2-Pad1_ /IN_Y4 10R
R6 /IN_X4 Net-_R6-Pad2_ 10R
U7 /EN_Y5 /LOW_Y5 /OUT_Y5 GND GND Net-_R10-Pad1_ /HI_Y5 +5V /EN_X5 /HI_X5 Net-_R14-Pad2_ GND GND /OUT_X5 /LOW_X5 /LOGIC_PWR SN754410
R10 Net-_R10-Pad1_ /IN_Y5 10R
R14 /IN_X5 Net-_R14-Pad2_ 10R
U5 /EN_Y6 /LOW_Y6 /OUT_Y6 GND GND Net-_R4-Pad1_ /HI_Y6 +5V /EN_X6 /HI_X6 Net-_R8-Pad2_ GND GND /OUT_X6 /LOW_X6 /LOGIC_PWR SN754410
R4 Net-_R4-Pad1_ /IN_Y6 10R
R8 /IN_X6 Net-_R8-Pad2_ 10R
U9 /EN_Y7 /LOW_Y7 /OUT_Y7 GND GND Net-_R12-Pad1_ /HI_Y7 +5V /EN_X7 /HI_X7 Net-_R16-Pad2_ GND GND /OUT_X7 /LOW_X7 /LOGIC_PWR SN754410
R12 Net-_R12-Pad1_ /IN_Y7 10R
R16 /IN_X7 Net-_R16-Pad2_ 10R
Q1 GND Net-_P8-Pad3_ Net-_P11-Pad1_ 2n3904
Q2 GND Net-_P8-Pad1_ Net-_P11-Pad1_ 2n3904
R17 /LOGIC_PWR Net-_C5-Pad2_ 10K
R18 NC_01 Net-_P11-Pad1_ 10K
D1 GND Net-_C5-Pad2_ 1N4148
C5 GND Net-_C5-Pad2_ 100N
P11 Net-_P11-Pad1_ SENSE_DATA
P8 Net-_P8-Pad1_ Net-_C5-Pad2_ Net-_P8-Pad3_ CONN_01X03
P7 Net-_P6-Pad2_ Net-_P6-Pad1_ CONN_01X02
P6 Net-_P6-Pad1_ Net-_P6-Pad2_ CONN_01X02
.end
