.title KiCad schematic
Q102 NC_01 GND Net-_Q102-Pad3_ BFR92
D115 Net-_D115-Pad1_ +5V LED
R110 Net-_Q102-Pad3_ Net-_D115-Pad1_ R
Q103 GPIO_IR6 GND Net-_Q103-Pad3_ BFR92
D116 Net-_D116-Pad1_ +5V LED
R111 Net-_Q103-Pad3_ Net-_D116-Pad1_ R
D119 Net-_D119-Pad1_ +5V LED
R114 Net-_Q104-Pad3_ Net-_D120-Pad1_ R
D120 Net-_D120-Pad1_ Net-_D119-Pad1_ LED
Q105 GPIO_IR45 GND Net-_Q105-Pad3_ BFR92
D121 Net-_D121-Pad1_ +5V LED
R115 Net-_Q105-Pad3_ Net-_D122-Pad1_ R
D122 Net-_D122-Pad1_ Net-_D121-Pad1_ LED
U101 GND +5V VBAT LD1117S50TR
C102 +5V GND 10u
C101 VBAT GND 100n
U104 GND +3V3 +5V LD1117S33TR
C103 +5V GND 100n
C104 +3V3 GND 10u
P103 M2+ M2- NC_02 NC_03 VDD GND CONN_01X06
P102 M1+ M1- NC_04 NC_05 VDD GND CONN_01X06
P104 Net-_P101-Pad2_ Net-_P104-Pad2_ CONN_01X02
P101 GND Net-_P101-Pad2_ CONN_01X02
SW101 VBAT Net-_P104-Pad2_ NC_06 SWITCH_INV
IC101 CURRENT1 M1+ M1- VCC M1_DIR M1_EN Net-_IC101-Pad7_ GND VCC M2_DIR M2_EN Net-_IC101-Pad12_ M2- M2+ CURRENT2 L298
R104 CURRENT2 GND 0.5
R103 CURRENT1 GND 0.5
D104 M1+ GND D
D106 M1- GND D
D109 M2- GND D
D111 M2+ GND D
D103 VCC M1+ D
D105 VCC M1- D
D108 VCC M2- D
D110 VCC M2+ D
Q104 GPIO_IR23 GND Net-_Q104-Pad3_ BFR92
U102 M1_DIR NC_07 Net-_IC101-Pad7_ NC_08 74AHC1G14
U103 M2_DIR NC_09 Net-_IC101-Pad12_ NC_10 74AHC1G14
R101 VBAT VOL_BAT 20k
R102 VOL_BAT GND 10k
D102 GND Net-_D102-Pad2_ LED
D107 GND Net-_D107-Pad2_ LED
R105 +5V Net-_D102-Pad2_ R
R106 +3V3 Net-_D107-Pad2_ R
47K102 NC_11 GND R
47K104 GPIO_IR23 GND R
47K103 GPIO_IR6 GND R
47K105 GPIO_IR45 GND R
BZ101 +3V3 BUZZER_CONTROL buzzer
Q101 GPIO_BUZZER GND BUZZER_CONTROL BFR92
47K101 GPIO_BUZZER GND R
D101 +3V3 BUZZER_CONTROL D
D114 Net-_D114-Pad1_ VA3.3 LED
R109 Net-_D114-Pad1_ AGND R
D117 Net-_D117-Pad1_ VA3.3 LED
R112 Net-_D117-Pad1_ AGND R
D118 Net-_D118-Pad1_ VA3.3 LED
R113 Net-_D118-Pad1_ AGND R
D123 Net-_D123-Pad1_ VA3.3 LED
R116 Net-_D123-Pad1_ AGND R
D112 Net-_D112-Pad1_ VA3.3 LED
R107 Net-_D112-Pad1_ AGND R
D113 Net-_D113-Pad1_ VA3.3 LED
R108 Net-_D113-Pad1_ AGND R
U105 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 ESP32-WROOM
U1 5V ADXRS620_breakout
U4 5V TPS73633
L2 V3.3 VA3.3 10uH
L3 GND AGND SPLITTER
L1 NC_51 GND SPLITTER
R1 5V Net-_D1-Pad2_ R
D1 GND Net-_D1-Pad2_ PWR_LED
C4 5V GND 0.1uF
C3 5V GND 10uF
C7 V3.3 GND 0.1uF
C6 NC_52 GND 10uF
C5 Net-_C5-Pad1_ NC_53 0.1uF
10uH1 A5V 5V INDUCTOR
U2 5V TPS76850
C2 VBAT NC_54 0.1uF
C1 VBAT GND 10uF
U5 NC_55 NC_56 GPIO_IR_SIDE GPIO_IR_SIDE GPIO_IR_DIAG GPIO_IR_DIAG GPIO_BUZZER GND NC_57 BUZZER_CONTROL Net-_R11-Pad2_ Net-_R11-Pad2_ Net-_R10-Pad2_ Net-_R10-Pad2_ Net-_R9-Pad2_ Net-_R8-Pad2_ ULN2003A
D9 Net-_D9-Pad1_ 5V LED
R9 Net-_D9-Pad1_ Net-_R9-Pad2_ R
D8 Net-_D8-Pad1_ 5V LED
R8 Net-_D8-Pad1_ Net-_R8-Pad2_ R
D10 Net-_D10-Pad1_ 5V LED
D11 Net-_D11-Pad1_ Net-_D10-Pad1_ LED
R10 Net-_D11-Pad1_ Net-_R10-Pad2_ R
D12 Net-_D12-Pad1_ 5V LED
D13 Net-_D13-Pad1_ Net-_D12-Pad1_ LED
R11 Net-_D13-Pad1_ Net-_R11-Pad2_ R
C9 5V GND C
C8 5V GND C
C11 5V GND C
C10 5V GND C
C13 5V GND C
C12 5V GND C
C15 5V GND C
C14 5V GND C
U3 GND DRV8825_pololu
R2 NC_58 Net-_D2-Pad2_ R
D2 GND Net-_D2-Pad2_ LED
R3 NC_59 Net-_D3-Pad2_ R
D3 GND Net-_D3-Pad2_ LED
R4 NC_60 Net-_D4-Pad2_ R
D4 GND Net-_D4-Pad2_ LED
R5 NC_61 Net-_D5-Pad2_ R
D5 GND Net-_D5-Pad2_ LED
R6 NC_62 Net-_D6-Pad2_ R
D6 GND Net-_D6-Pad2_ LED
R7 NC_63 Net-_D7-Pad2_ R
D7 GND Net-_D7-Pad2_ LED
.end
