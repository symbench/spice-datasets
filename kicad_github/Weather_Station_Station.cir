.title KiCad schematic
U1 Net-_C9-Pad1_ Net-_C10-Pad1_ NC_01 /SAMD21/AREF NC_02 Net-_C7-Pad1_ NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 +3V3 Net-_U1-Pad18_ NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 Net-_U1-Pad18_ +3V3 NC_29 NC_30 NC_31 /SAMD21/~RESET_SAMD NC_32 Net-_U1-Pad18_ Net-_C6-Pad1_ NC_33 /SAMD21/SWCLK /SAMD21/SWDIO NC_34 NC_35 ATSAMD21G18A-AUT-MCU_Microchip_SAMD_Redone
C1 +3V3 GND 0.1uF
C2 +3V3 GND 10uF
C3 /SAMD21/AREF GND 1uF
C5 +3V3 GND 0.1uF
C4 +3V3 GND 10uF
C6 Net-_C6-Pad1_ GND 1uF
C7 Net-_C7-Pad1_ GND 10uF
C8 Net-_C7-Pad1_ GND 0.1uF
L1 +3V3 Net-_C7-Pad1_ 10uH
Y1 Net-_C9-Pad1_ Net-_C10-Pad1_ 32768Hz
C9 Net-_C9-Pad1_ GND 10pF
C10 Net-_C10-Pad1_ GND 10pF
TP1 /SAMD21/SWCLK TestPoint
TP2 /SAMD21/SWDIO TestPoint
SW1 /SAMD21/~RESET_SAMD GND SW_SPST
U2 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 BME680
U3 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 AS3935
R1 NC_60 NC_61 ALS-PT19-315C_L177_TR8
IC1 /Power/VBUS GND +3V3 GND MIC39100-3.3WS
U4 NC_62 NC_63 NC_64 NC_65 NC_66 MCP73831-2-OT
J1 /Power/VBUS NC_67 NC_68 NC_69 GND NC_70 USB_B_Micro
C11 /Power/VBUS GND 1uF
C12 +3V3 GND 1uF
C13 +3V3 GND 0.1uF
U5 Net-_U5-Pad1_ NC_71 NC_72 Net-_U5-Pad1_ Net-_U5-Pad1_ Net-_U5-Pad1_ NC_73 NC_74 NC_75 Net-_U5-Pad1_ Net-_U5-Pad1_ NC_76 NC_77 NC_78 Net-_U5-Pad1_ Net-_U5-Pad1_ NC_79 NC_80 NC_81 Net-_U5-Pad1_ ublox_SAM-M8Q
U6 NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 RFM95W-915S2
J2 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 Micro_SD_Card_Det
.end
