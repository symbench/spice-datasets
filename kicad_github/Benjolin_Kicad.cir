.title KiCad schematic
D6 FCV Net-_D5-Pad1_ 1N914
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ 1N914
D4 VCA3CV Net-_D2-Pad1_ 1N914
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ 1N914
D3 VCA4CV Net-_D1-Pad1_ 1N914
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ 1N914
C17 NC_01 NC_02 100n
C16 NC_03 NC_04 100n
C14 GND V+ 100n
C11 GND +12V 100n
C1 Net-_C1-Pad1_ NC_05 100n
C7 T2 VCA3Out 1n
C6 T1 VCA4Out 1n
C10 OUT VCA1Out 220p
C8 Net-_C5-Pad1_ VCA2Out 220p
C5 Net-_C5-Pad1_ VCA2In 220p
C3 GND Net-_C3-Pad2_ 560p
C2 GND Net-_C2-Pad2_ 560p
C9 GND Net-_C9-Pad2_ 560p
C4 GND Net-_C4-Pad2_ 560p
C18 NC_06 NC_07 10uf
C15 V+ GND 10uf
C13 GND -12V 10uf
C12 +12V GND 10uf
R27 GND P9R2B 1.5k
R9 P1 Net-_Q1-Pad2_ 100k
R36 P2 VCA3In 100k
R35 P1 VCA4In 100k
R32 Net-_C5-Pad1_ Net-_D5-Pad2_ 100k
R31 Net-_R31-Pad1_ Net-_R10-Pad1_ 100k
R18 Net-_R17-Pad1_ Net-_R10-Pad1_ 100k
R49 RUN_CV Net-_R37-Pad1_ 10k
R33 FCV Net-_D5-Pad2_ 10k
R14 GND Net-_R10-Pad1_ 10k
R13 VCA3CV Net-_D2-Pad2_ 10k
R12 VCA4CV Net-_D1-Pad2_ 10k
R11 Net-_R10-Pad1_ PWM 150k
R19 XOR Net-_R15-Pad2_ 15k
R41 Net-_R41-Pad1_ T2 15k
R40 Net-_R40-Pad1_ T1 15k
R44 Net-_R39-Pad1_ Net-_R38-Pad1_ 15k
R43 Net-_R38-Pad1_ Net-_R37-Pad1_ 15k
R26 P9R2B VCA2In 15k
R8 Net-_Q1-Pad1_ Net-_R15-Pad1_ 30k
R15 Net-_R15-Pad1_ Net-_R15-Pad2_ 30k
R39 Net-_R39-Pad1_ Net-_R15-Pad1_ 30k
R38 Net-_R38-Pad1_ Net-_R38-Pad2_ 30k
R37 Net-_R37-Pad1_ Net-_R37-Pad2_ 30k
R47 P1 Net-_R40-Pad1_ 30k
R48 P2 Net-_R41-Pad1_ 30k
R20 OUT Net-_R17-Pad1_ 30k
R22 VCA2In Net-_R21-Pad1_ 30k
R21 Net-_R21-Pad1_ Net-_R17-Pad1_ 30k
R5 Net-_D2-Pad2_ NC_08 30k
R2 Net-_D1-Pad2_ NC_09 30k
R42 VCA1In Net-_C5-Pad1_ 30k
R34 P9R3B Net-_R31-Pad1_ 30k
R45 GND Net-_R39-Pad1_ 30k
R50 OUT VCA1In 470k
R24 Net-_C3-Pad2_ VCA3In 510r
R23 Net-_C2-Pad2_ VCA4In 510r
R46 Net-_C9-Pad2_ VCA1In 510r
R25 Net-_C4-Pad2_ VCA2In 510r
R29 Net-_D5-Pad2_ NC_10 51k
R30 Net-_D5-Pad2_ NC_11 51k
R10 Net-_R10-Pad1_ RUN_CV 51k
R4 Net-_D1-Pad2_ NC_12 51k
R17 Net-_R17-Pad1_ Net-_C1-Pad1_ 51k
R3 Net-_D1-Pad2_ NC_13 51k
R28 Net-_D5-Pad2_ NC_14 51k
R6 Net-_D2-Pad2_ NC_15 51k
R1 NC_16 Net-_R1-Pad2_ 62k
R16 GND Net-_Q1-Pad1_ 62k
RV1 V+ NC_17 V- 10k
P2R1 Net-_J15-PadT_ NC_18 GND 10k
P11R1 Net-_J5-PadT_ NC_19 GND 10k
P10R1 V-F NC_20 GND 10k
P8R1 RUN_CVF NC_21 GND 10k
P6R1 RUN_CVF NC_22 GND 10k
P4R1 V-F NC_23 GND 10k
P1R1 Net-_J14-PadT_ NC_24 GND 10k
P5R1 RUN_CVF NC_25 GND 10k
P3R1 V-F NC_26 GND 10k
P9R1 GND NC_27 NC_28 10k
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ GND BC547
J2 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 Conn_02x05_Row_Letter_Last
J3 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 Conn_02x05_Row_Letter_Last
J13 GND NC_49 NC_50 XOR
J12 GND RUN_CVF NC_51 RUN
J11 GND NC_52 NC_53 PWM
J10 GND NC_54 NC_55 MAINOUT
J14 GND Net-_J14-PadT_ NC_56 CV_1
J15 NC_57 Net-_J15-PadT_ NC_58 CV_2
J9 GND NC_59 NC_60 PUL1
J8 GND NC_61 NC_62 TRI2
J7 GND NC_63 NC_64 TRI1
J6 GND NC_65 NC_66 PUL2
J5 GND Net-_J5-PadT_ NC_67 CV_F
J4 GND NC_68 NC_69 EXT.INPUT
SW1 Net-_R1-Pad2_ Net-_Q1-Pad2_ NC_70 SW_SPDT
U5 NC_71 VCA1In FCV VCA1Out VCA2Out FCV VCA2In GND V- VCA3In VCA3CV VCA3Out VCA4Out VCA4CV VCA4In V+ SSI2164
U2 P2 GND Net-_R41-Pad1_ V- Net-_R40-Pad1_ GND P1 V+ TL072
U1 Net-_D2-Pad1_ Net-_D2-Pad2_ GND V+ GND VCA3Out T2 Net-_D1-Pad1_ Net-_D1-Pad2_ GND V- GND VCA4Out T1 TL074
U6 NC_72 Net-_R37-Pad2_ Net-_R15-Pad1_ NC_73 NC_74 NC_75 NC_76 NC_77 V- P2 XOR Net-_R38-Pad2_ NC_78 NC_79 NC_80 NC_81 4021
U3 P9R3B Net-_R31-Pad1_ Net-_C5-Pad1_ V+ GND VCA1Out OUT XOR Net-_R15-Pad2_ Net-_Q1-Pad1_ V- GND Net-_R37-Pad1_ RUN_CV TL074
U4 Net-_R21-Pad1_ Net-_R17-Pad1_ GND V+ GND VCA2Out Net-_C5-Pad1_ PWM T1 T2 V- GND Net-_D5-Pad2_ Net-_D5-Pad1_ TL074
R7 Net-_D2-Pad2_ NC_82 51k
J1 GND +12V -12V Conn_01x03_Female
U7 V+ GND +12V L78L09_SOT89
.end
