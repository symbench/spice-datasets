.title KiCad schematic
IC1 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 VCC GND NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 /CS /SCK /MOSI /MISO NC_17 Net-_D3-Pad2_ Net-_D4-Pad2_ Net-_IC1-Pad26_ NC_18 NC_19 NC_20 /RESET VCC GND Net-_IC1-Pad33_ Net-_IC1-Pad34_ NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 /SCL /SDA Net-_IC1-Pad45_ Net-_IC1-Pad46_ NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 VCC GND NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 Net-_IC1-Pad78_ NC_58 VCC GND NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 Net-_C2-Pad1_ GND VCC ATMEGA2560-A
Y1 Net-_IC1-Pad34_ GND Net-_IC1-Pad33_ RESONATOR
R1 Net-_IC1-Pad34_ Net-_IC1-Pad33_ 1M
MTG?1 MTG_HOLE
MTG3 MTG_HOLE
MTG2 MTG_HOLE
MTG1 MTG_HOLE
R2 VCC /RESET 10K
C1 /RESET GND C
D1 /RESET VCC DIODE
R3 VCC /SCL 10K
R4 VCC /SDA 10K
CON1 NC_75 Net-_CON1-Pad2_ Net-_CON1-Pad3_ Net-_CON1-Pad4_ Net-_CON1-Pad5_ GND /MISO NC_76 GND Micro_SD_Card
U3 GND NC_77 VCC Net-_CON1-Pad4_ AP1117
U2 Net-_CON1-Pad4_ Net-_CON1-Pad3_ /MOSI Net-_CON1-Pad2_ /CS Net-_CON1-Pad5_ /SCK GND /SCK Net-_D2-Pad2_ GND NC_78 GND NC_79 4050
J1 /MISO VCC /SCK /MOSI /RESET GND ISP
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED-fixed
R5 Net-_D2-Pad1_ Net-_CON1-Pad2_ 1K
U4 GND Net-_J2-Pad1_ GND VCC BuckConverter
J2 Net-_J2-Pad1_ GND GND DCJ0202
C2 Net-_C2-Pad1_ GND 100n
C3 VCC GND 100n
C4 VCC GND 100n
C5 VCC GND 100n
U1 GND VCC /SDA /SCL I2C-4PIN
P1 VCC GND Net-_IC1-Pad45_ Net-_IC1-Pad46_ CONN_01X04
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ LED-fixed
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED-fixed
R6 Net-_D4-Pad1_ GND 330
R7 Net-_D3-Pad1_ GND 330
P2 GND VCC /SDA /SCL Net-_IC1-Pad78_ CONN_01X05
P3 Net-_IC1-Pad26_ VCC GND CONN_01X03
.end
