.title KiCad schematic
U1 LED DATA GND GND SDA SCL SW32A row0 row1 row2 row3 row4 col5 col4 col3 col2 col1 col0 ENCB ENCA VCC RESET GND NC_01 ProMicro
SW28 col4 Net-_D28-Pad2_ SW_PUSH
SW1 col5 Net-_D1-Pad2_ SW_PUSH
D1 row0 Net-_D1-Pad2_ D
SW2 col4 Net-_D2-Pad2_ SW_PUSH
D2 row0 Net-_D2-Pad2_ D
SW3 col3 Net-_D3-Pad2_ SW_PUSH
D3 row0 Net-_D3-Pad2_ D
SW4 col2 Net-_D4-Pad2_ SW_PUSH
D4 row0 Net-_D4-Pad2_ D
SW5 col1 Net-_D5-Pad2_ SW_PUSH
D5 row0 Net-_D5-Pad2_ D
SW6 col0 Net-_D6-Pad2_ SW_PUSH
D6 row0 Net-_D6-Pad2_ D
SW9 col4 Net-_D9-Pad2_ SW_PUSH
SW10 col3 Net-_D10-Pad2_ SW_PUSH
SW11 col2 Net-_D11-Pad2_ SW_PUSH
SW12 col1 Net-_D12-Pad2_ SW_PUSH
SW13 col0 Net-_D13-Pad2_ SW_PUSH
SW8 col5 Net-_D8-Pad2_ SW_PUSH
D8 row1 Net-_D8-Pad2_ D
D9 row1 Net-_D9-Pad2_ D
D10 row1 Net-_D10-Pad2_ D
D11 row1 Net-_D11-Pad2_ D
D12 row1 Net-_D12-Pad2_ D
D13 row1 Net-_D13-Pad2_ D
SW15 col5 Net-_D15-Pad2_ SW_PUSH
SW16 col4 Net-_D16-Pad2_ SW_PUSH
SW17 col3 Net-_D17-Pad2_ SW_PUSH
SW18 col2 Net-_D18-Pad2_ SW_PUSH
SW19 col1 Net-_D19-Pad2_ SW_PUSH
SW20 col0 Net-_D20-Pad2_ SW_PUSH
D15 row2 Net-_D15-Pad2_ D
D16 row2 Net-_D16-Pad2_ D
D17 row2 Net-_D17-Pad2_ D
D18 row2 Net-_D18-Pad2_ D
D19 row2 Net-_D19-Pad2_ D
D20 row2 Net-_D20-Pad2_ D
SW24 col3 Net-_D24-Pad2_ SW_PUSH
SW25 col2 Net-_D25-Pad2_ SW_PUSH
SW26 col1 Net-_D26-Pad2_ SW_PUSH
SW27 col0 Net-_D27-Pad2_ SW_PUSH
SW23 col4 Net-_D23-Pad2_ SW_PUSH
SW22 col5 Net-_D22-Pad2_ SW_PUSH
D22 row3 Net-_D22-Pad2_ D
D23 row3 Net-_D23-Pad2_ D
D24 row3 Net-_D24-Pad2_ D
D25 row3 Net-_D25-Pad2_ D
D26 row3 Net-_D26-Pad2_ D
D27 row3 Net-_D27-Pad2_ D
SW29 col3 Net-_D29-Pad2_ SW_PUSH
SW30 col2 Net-_D30-Pad2_ SW_PUSH
SW31 col1 Net-_D31-Pad2_ SW_PUSH
D28 row4 Net-_D28-Pad2_ D
D29 row4 Net-_D29-Pad2_ D
D30 row4 Net-_D30-Pad2_ D
D31 row4 Net-_D31-Pad2_ D
R1 VCC SDA R
R2 VCC SCL R
J2 VCC GND /i2c_d /i2c_c 4PIN
J1 VCC LED GND LED
TH1 HOLE
TH2 HOLE
TH4 HOLE
TH5 HOLE
TH6 HOLE
TH7 HOLE
TH3 HOLE
RSW1 GND RESET SW_RST
P1 /i2c_c i2c_pin
P2 /i2c_d i2c_pin
W1 DATA /i2c_d jumper
J3 SDA SCL VCC GND OLED
SW32 ENCA ENCB GND SW32A SW32B Rotary_Encoder_Switch
SW0 SW32A Net-_D0-Pad2_ SW_PUSH
D0 row0 Net-_D0-Pad2_ D
SW7 SW32A Net-_D7-Pad2_ SW_PUSH
D7 row1 Net-_D7-Pad2_ D
SW14 SW32A Net-_D14-Pad2_ SW_PUSH
D14 row2 Net-_D14-Pad2_ D
SW21 SW32A Net-_D21-Pad2_ SW_PUSH
D21 row3 Net-_D21-Pad2_ D
D32 row4 SW32B D
.end
