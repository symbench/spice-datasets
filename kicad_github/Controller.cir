.title KiCad schematic
IC2 Net-_C7-Pad2_ Net-_C5-Pad2_ NC_01 NC_02 GND SD_CD NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 Net-_IC2-Pad13_ GND SD_CD Net-_IC2-Pad16_ NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 GND SD_CD NC_17 NC_18 NC_19 NC_20 GND SD_CD FLASH_IO0 FLASH_IO1 FLASH_IO2 FLASH_IO3 SD_CD GND FLASH_SCK FLASH_CS NC_21 NC_22 NC_23 NC_24 GND SD_CD NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 GND SD_CD NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 GND SD_CD NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 GND SD_CD NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 GND SD_CD NC_62 NC_63 D- D+ GND SD_CD NC_64 NC_65 NC_66 NC_67 SD_MOSI SD_SCK SD_CS SD_MISO GND SD_CD RGBLED Net-_IC2-Pad109_ Net-_IC2-Pad110_ Net-_IC2-Pad111_ Net-_IC2-Pad112_ Net-_IC2-Pad113_ Net-_C21-Pad1_ Net-_C3-Pad1_ GND Net-_IC2-Pad117_ SD_CD NC_68 SWDIO SWO SD_CD TXLED RXLED NC_69 D13 NC_70 NC_71 ATSAMD51P20A-AF
L1 Net-_C3-Pad1_ Net-_IC2-Pad117_ L
C6 Net-_C3-Pad1_ GND C
C4 Net-_C3-Pad1_ GND CP
C3 Net-_C3-Pad1_ GND CP
C13 SD_CD GND C
C14 SD_CD GND C
C15 SD_CD GND C
C16 SD_CD GND C
C17 SD_CD GND C
C8 SD_CD GND C
C9 SD_CD GND C
C10 SD_CD GND C
C11 SD_CD GND C
C12 SD_CD GND C
C18 SD_CD GND C
C19 SD_CD GND C
C20 SD_CD GND C
C21 Net-_C21-Pad1_ GND C
R10 SD_CD Net-_C21-Pad1_ R
Y1 Net-_C5-Pad2_ Net-_C7-Pad2_ Crystal
C5 GND Net-_C5-Pad2_ C
C7 GND Net-_C7-Pad2_ C
R6 GND Net-_IC2-Pad112_ R
R7 GND Net-_IC2-Pad111_ R
R8 GND Net-_IC2-Pad110_ R
R9 GND Net-_IC2-Pad109_ R
R5 GND Net-_IC2-Pad13_ R
R4 GND Net-_IC2-Pad16_ R
D6 Net-_D6-Pad1_ SD_CD LED
R11 Net-_D6-Pad1_ RXLED R
D7 Net-_D7-Pad1_ SD_CD LED
R12 Net-_D7-Pad1_ TXLED R
D8 Net-_D8-Pad1_ SD_CD LED
R13 Net-_D8-Pad1_ GND R
D9 Net-_D9-Pad1_ D13 LED
R14 Net-_D9-Pad1_ GND R
J2 SD_CD SWDIO GND SWDCLK GND SWO NC_72 NC_73 NC_74 NC_75 Conn_ARM_JTAG_SWD_10
R1 SWDCLK SD_CD R
IC1 FLASH_CS FLASH_IO1 FLASH_IO2 GND FLASH_IO0 FLASH_SCK FLASH_IO3 Net-_C2-Pad1_ W25Q64JVSSIM_TR
C2 Net-_C2-Pad1_ GND C
J1 NC_76 SD_CS SD_MOSI SD_CD SD_SCK GND SD_MISO NC_77 GND GND GND SD_CD GND DM3CS-SF
C1 SD_CD GND C
D2 SD_CD Net-_D2-Pad2_ GND RGBLED WS2812B
D3 SD_CD Net-_D3-Pad2_ GND Net-_D2-Pad2_ WS2812B
D4 SD_CD Net-_D4-Pad2_ GND Net-_D3-Pad2_ WS2812B
D5 SD_CD NC_78 GND Net-_D4-Pad2_ WS2812B
D1 GND D+ D- SD_CD PRTR5V0U2X
J3 NC_79 D+ D- GND 5787834-1
R2 SD_CD Net-_IC2-Pad113_ R
R3 Net-_IC2-Pad113_ GND R
.end
