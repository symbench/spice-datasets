.title KiCad schematic
LOGO1 BUTTERFLY_LOGO
R9 GND SW_FUNCTION 47K
R10 GND SW_SELECT 47K
R17 GND SW_RESET 47K
R44 Net-_LED4-PadA_ /BPS6001 Classic Computing Shield_1/LED4 390
R43 Net-_LED3-PadA_ /BPS6001 Classic Computing Shield_1/LED3 390
R27 Net-_LED2-PadA_ /BPS6001 Classic Computing Shield_1/LED2 390
R26 Net-_LED1-PadA_ /BPS6001 Classic Computing Shield_1/LED1 390
LED4 Net-_LED4-PadA_ GND LEDCHIPLED_0603
LED3 Net-_LED3-PadA_ GND LEDCHIPLED_0603
LED2 Net-_LED2-PadA_ GND LEDCHIPLED_0603
LED1 Net-_LED1-PadA_ GND LEDCHIPLED_0603
S1 SW_FUNCTION SW_FUNCTION 3V3_PWR6 3V3_PWR6 EVQQ2
S2 SW_SELECT SW_SELECT 3V3_PWR6 3V3_PWR6 EVQQ2
S3 SW_RESET SW_RESET 3V3_PWR6 3V3_PWR6 EVQQ2
H1 3V3_PWR6 5V0 5V 5V JS1_9 JS1_4 JS1_3 JS1_7 JS1_2 JS1_6 JS1_1 SD_~CS SD_SCK SD_MOSI SD_MISO NC_01 JS1_5 IEC-L-DATA IEC-L-CLK IEC-L-ATN IEC-L-RESET IEC-L-SRQ NC_02 NC_03 HORIZONTAL_SYNC JS2_5 VERTICAL_SYNC JS2_4 BLUE1 JS2_3 SW_SELECT JS2_2 SW_RESET JS2_1 BLUE2 JS2_6 BLUE3 JS2_7 BLUE4 JS2_9 GREEN1 /BPS6001 Classic Computing Shield_1/PS2CLK2 GREEN2 /BPS6001 Classic Computing Shield_1/PS2DAT2 GREEN3 AUDIO2-RIGHT GREEN4 AUDIO2-LEFT RED4 /BPS6001 Classic Computing Shield_1/LED1 RED3 /BPS6001 Classic Computing Shield_1/LED2 RED2 /BPS6001 Classic Computing Shield_1/LED3 RED1 /BPS6001 Classic Computing Shield_1/LED4 GND GND GND GND GND NC_04 NC_05 NC_06 NC_07 Arduino Mega Header
PWR_2 GND NC_08 3V3_PWR6 5V0 POWER_ONLYNOTEXT
PWR_1 GND NC_09 3V3_PWR6 NC_10 POWER_ONLYNOTEXT
R47 /BPS6001 Classic Computing Shield_1/PS2DAT2 Net-_PS2_B1-Pad1_ 390
R48 /BPS6001 Classic Computing Shield_1/PS2CLK2 Net-_PS2_B1-Pad5_ 390
PS2_B1 Net-_PS2_B1-Pad1_ NC_11 GND 5V0 Net-_PS2_B1-Pad5_ NC_12 MINI-DIN6PTH
J1 SW_FUNCTION 3V3_PWR6 SW_SELECT 3V3_PWR6 SW_RESET 3V3_PWR6 Conn_02x03_Row_Letter_Last
SD1 NC_13 SD_~CS SD_MOSI 3V3_PWR6 SD_SCK GND SD_MISO NC_14 NC_15 NC_16 GND GND MICROSD
R23 SD_MISO 3V3_PWR6 47K
R24 SD_MOSI 3V3_PWR6 47K
R25 SD_~CS 3V3_PWR6 47K
JS1 JS1_1 JS1_2 JS1_3 JS1_4 JS1_5 JS1_6 JS1_7 GND JS1_9 Serial Port
R8 JS1_5 3V3_PWR6 47K
R6 JS1_4 3V3_PWR6 47K
R5 JS1_3 3V3_PWR6 47K
R3 JS1_2 3V3_PWR6 47K
R1 JS1_1 3V3_PWR6 47K
R2 JS1_6 3V3_PWR6 47K
R4 JS1_7 3V3_PWR6 47K
R7 JS1_9 3V3_PWR6 47K
JS2 JS2_1 JS2_2 JS2_3 JS2_4 JS2_5 JS2_6 JS2_7 GND JS2_9 Serial Port
R12 JS2_5 3V3_PWR6 47K
R13 JS2_4 3V3_PWR6 47K
R14 JS2_3 3V3_PWR6 47K
R15 JS2_2 3V3_PWR6 47K
R16 JS2_1 3V3_PWR6 47K
R19 JS2_6 3V3_PWR6 47K
R20 JS2_7 3V3_PWR6 47K
R21 JS2_9 3V3_PWR6 47K
AJ2 GND GND Net-_AJ2-PadL_ NC_17 Net-_AJ2-PadR_ NC_18 AUDIO-CONNECTOR-6P-SMD-3440030P1
C8 Net-_AJ2-PadL_ GND 4700pF
R45 Net-_AJ2-PadL_ AUDIO2-LEFT 3.3K
C9 Net-_AJ2-PadR_ GND 4700pF
R46 Net-_AJ2-PadR_ AUDIO2-RIGHT 3.3K
X2 IEC-H-SRQ GND IEC-H-ATN IEC-H-CLK IEC-H-DATA IEC-H-RESET GND GND MAB6H
C1 5V0 GND 100nF
C3 GND 3V3_PWR6 100nF
Q0 3V3_PWR6 IEC-L-RESET IEC-H-RESET BSS138
R60 3V3_PWR6 IEC-L-RESET 10K
R61 5V0 IEC-H-RESET 10K
C40 IEC-H-RESET GND 15pF
Q1 3V3_PWR6 IEC-L-DATA IEC-H-DATA BSS138
R62 3V3_PWR6 IEC-L-DATA 10K
R63 5V0 IEC-H-DATA 10K
C41 IEC-H-DATA GND 15pF
Q2 3V3_PWR6 IEC-L-CLK IEC-H-CLK BSS138
R64 3V3_PWR6 IEC-L-CLK 10K
R65 5V0 IEC-H-CLK 10K
C42 IEC-H-CLK GND 15pF
Q3 3V3_PWR6 IEC-L-ATN IEC-H-ATN BSS138
R66 3V3_PWR6 IEC-L-ATN 10K
R67 5V0 IEC-H-ATN 10K
C43 IEC-H-ATN GND 15pF
Q4 3V3_PWR6 IEC-L-SRQ IEC-H-SRQ BSS138
R69 5V0 IEC-H-SRQ 10K
C44 IEC-H-SRQ GND 15pF
R68 3V3_PWR6 IEC-L-SRQ 10K
X1 /4096 VGA/RED /4096 VGA/GREEN /4096 VGA/BLUE NC_19 NC_20 GND GND GND NC_21 GND GND NC_22 Net-_R29-Pad2_ Net-_R30-Pad2_ NC_23 VGA
R42 RED1 /4096 VGA/RED 3.9K
R35 GREEN1 /4096 VGA/GREEN 3.9K
R31 BLUE1 /4096 VGA/BLUE 3.9K
R29 HORIZONTAL_SYNC Net-_R29-Pad2_ 82.5
R30 VERTICAL_SYNC Net-_R30-Pad2_ 82.5
R41 RED2 /4096 VGA/RED 2K
R36 GREEN2 /4096 VGA/GREEN 2K
R32 BLUE2 /4096 VGA/BLUE 2K
R40 RED3 /4096 VGA/RED 1K
R39 RED4 /4096 VGA/RED 510
R37 GREEN3 /4096 VGA/GREEN 1K
R38 GREEN4 /4096 VGA/GREEN 510
R33 BLUE3 /4096 VGA/BLUE 1K
R34 BLUE4 /4096 VGA/BLUE 510
.end
