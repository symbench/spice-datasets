.title KiCad schematic
U4 /N2_8 /N2_9 /N2_A /N2_D +5V /N2_B /N2_C /N2_2 /N2_3 /N2_7 /N2_6 GND /N2_4 /N2_5 /N2_1 /N2_0 74141
U3 /N1_8 /N1_9 /N1_A /N1_D +5V /N1_B /N1_C /N1_2 /N1_3 /N1_7 /N1_6 GND /N1_4 /N1_5 /N1_1 /N1_0 74141
U1 /N1_B /N1_C /N1_D /N2_A /N2_B /N2_C /N2_D GND Net-_U1-Pad9_ +5V SRCLK SRLATCH GND NC_01 /N1_A +5V 74HC595
N1 /N1_0 /N1_1 /N1_2 /N1_3 /N1_4 /N1_5 /N1_6 /N1_7 /N1_8 /N1_9 /AnodeN1 IN-2
C9 +5V GND 0.1uF
R10 +170V /AnodeN1 22k
N2 /N2_0 /N2_1 /N2_2 /N2_3 /N2_4 /N2_5 /N2_6 /N2_7 /N2_8 /N2_9 /AnodeN2 IN-2
R11 +170V /AnodeN2 22k
U6 /N4_8 /N4_9 /N4_A /N4_D +5V /N4_B /N4_C /N4_2 /N4_3 /N4_7 /N4_6 GND /N4_4 /N4_5 /N4_1 /N4_0 74141
U5 /N3_8 /N3_9 /N3_A /N3_D +5V /N3_B /N3_C /N3_2 /N3_3 /N3_7 /N3_6 GND /N3_4 /N3_5 /N3_1 /N3_0 74141
U2 /N3_B /N3_C /N3_D /N4_A /N4_B /N4_C /N4_D GND Net-_U2-Pad9_ +5V SRCLK SRLATCH GND Net-_U1-Pad9_ /N3_A +5V 74HC595
N3 /N3_0 /N3_1 /N3_2 /N3_3 /N3_4 /N3_5 /N3_6 /N3_7 /N3_8 /N3_9 /AnodeN3 IN-12A
C11 +5V GND 0.1uF
R12 +170V /AnodeN3 12k
N4 /N4_0 /N4_1 /N4_2 /N4_3 /N4_4 /N4_5 /N4_6 /N4_7 /N4_8 /N4_9 /AnodeN4 IN-12A
R13 +170V /AnodeN4 12k
U9 /N6_8 /N6_9 /N6_A /N6_D +5V /N6_B /N6_C /N6_2 /N6_3 /N6_7 /N6_6 GND /N6_4 /N6_5 /N6_1 /N6_0 74141
U8 /N5_8 /N5_9 /N5_A /N5_D +5V /N5_B /N5_C /N5_2 /N5_3 /N5_7 /N5_6 GND /N5_4 /N5_5 /N5_1 /N5_0 74141
U7 /N5_B /N5_C /N5_D /N6_A /N6_B /N6_C /N6_D GND NC_02 +5V SRCLK SRLATCH GND Net-_U2-Pad9_ /N5_A +5V 74HC595
N5 /N5_0 /N5_1 /N5_2 /N5_3 /N5_4 /N5_5 /N5_6 /N5_7 /N5_8 /N5_9 /AnodeN5 IN-1
C10 +5V GND 0.1uF
R14 +170V /AnodeN5 15k
N6 /N6_0 /N6_1 /N6_2 /N6_3 /N6_4 /N6_5 /N6_6 /N6_7 /N6_8 /N6_9 /AnodeN6 IN-1
R15 +170V /AnodeN6 15k
.end
