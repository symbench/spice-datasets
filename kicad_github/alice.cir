.title KiCad schematic
K1 Net-_K1-Pad1_ Net-_D1-Pad2_ KEYSW
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ D
K2 Net-_K19-Pad1_ Net-_D2-Pad2_ KEYSW
D2 Net-_D1-Pad1_ Net-_D2-Pad2_ D
K3 Net-_K20-Pad1_ Net-_D3-Pad2_ KEYSW
D3 Net-_D1-Pad1_ Net-_D3-Pad2_ D
K4 NC_01 Net-_D4-Pad2_ KEYSW
D4 Net-_D1-Pad1_ Net-_D4-Pad2_ D
K5 Net-_K21-Pad1_ Net-_D5-Pad2_ KEYSW
D5 Net-_D1-Pad1_ Net-_D5-Pad2_ D
K6 Net-_K22-Pad1_ Net-_D6-Pad2_ KEYSW
D6 Net-_D1-Pad1_ Net-_D6-Pad2_ D
K7 Net-_K23-Pad1_ Net-_D7-Pad2_ KEYSW
D7 Net-_D1-Pad1_ Net-_D7-Pad2_ D
K8 Net-_K24-Pad1_ Net-_D8-Pad2_ KEYSW
D8 Net-_D1-Pad1_ Net-_D8-Pad2_ D
K9 Net-_K25-Pad1_ Net-_D9-Pad2_ KEYSW
D9 Net-_D1-Pad1_ Net-_D9-Pad2_ D
K10 Net-_K10-Pad1_ Net-_D10-Pad2_ KEYSW
D10 Net-_D1-Pad1_ Net-_D10-Pad2_ D
K11 Net-_K11-Pad1_ Net-_D11-Pad2_ KEYSW
D11 Net-_D1-Pad1_ Net-_D11-Pad2_ D
K12 Net-_K12-Pad1_ Net-_D12-Pad2_ KEYSW
D12 Net-_D1-Pad1_ Net-_D12-Pad2_ D
K13 Net-_K13-Pad1_ Net-_D13-Pad2_ KEYSW
D13 Net-_D1-Pad1_ Net-_D13-Pad2_ D
K14 Net-_K14-Pad1_ Net-_D14-Pad2_ KEYSW
D14 Net-_D1-Pad1_ Net-_D14-Pad2_ D
K15 Net-_K15-Pad1_ Net-_D15-Pad2_ KEYSW
D15 Net-_D1-Pad1_ Net-_D15-Pad2_ D
K16 Net-_K16-Pad1_ Net-_D16-Pad2_ KEYSW
D16 Net-_D1-Pad1_ Net-_D16-Pad2_ D
K18 Net-_K1-Pad1_ Net-_D17-Pad2_ KEYSW
D17 Net-_D17-Pad1_ Net-_D17-Pad2_ D
K19 Net-_K19-Pad1_ Net-_D18-Pad2_ KEYSW
D18 Net-_D17-Pad1_ Net-_D18-Pad2_ D
K20 Net-_K20-Pad1_ Net-_D19-Pad2_ KEYSW
D19 Net-_D17-Pad1_ Net-_D19-Pad2_ D
K21 Net-_K21-Pad1_ Net-_D20-Pad2_ KEYSW
D20 Net-_D17-Pad1_ Net-_D20-Pad2_ D
K22 Net-_K22-Pad1_ Net-_D21-Pad2_ KEYSW
D21 Net-_D17-Pad1_ Net-_D21-Pad2_ D
K23 Net-_K23-Pad1_ Net-_D22-Pad2_ KEYSW
D22 Net-_D17-Pad1_ Net-_D22-Pad2_ D
K24 Net-_K24-Pad1_ Net-_D23-Pad2_ KEYSW
D23 Net-_D17-Pad1_ Net-_D23-Pad2_ D
K25 Net-_K25-Pad1_ Net-_D24-Pad2_ KEYSW
D24 Net-_D17-Pad1_ Net-_D24-Pad2_ D
K26 Net-_K10-Pad1_ Net-_D25-Pad2_ KEYSW
D25 Net-_D17-Pad1_ Net-_D25-Pad2_ D
K27 Net-_K11-Pad1_ Net-_D26-Pad2_ KEYSW
D26 Net-_D17-Pad1_ Net-_D26-Pad2_ D
K28 Net-_K12-Pad1_ Net-_D27-Pad2_ KEYSW
D27 Net-_D17-Pad1_ Net-_D27-Pad2_ D
K29 Net-_K13-Pad1_ Net-_D28-Pad2_ KEYSW
D28 Net-_D17-Pad1_ Net-_D28-Pad2_ D
K30 Net-_K14-Pad1_ Net-_D29-Pad2_ KEYSW
D29 Net-_D17-Pad1_ Net-_D29-Pad2_ D
K31 Net-_K15-Pad1_ Net-_D30-Pad2_ KEYSW
D30 Net-_D17-Pad1_ Net-_D30-Pad2_ D
K32 Net-_K16-Pad1_ Net-_D31-Pad2_ KEYSW
D31 Net-_D17-Pad1_ Net-_D31-Pad2_ D
K33 Net-_K1-Pad1_ Net-_D32-Pad2_ KEYSW
D32 Net-_D32-Pad1_ Net-_D32-Pad2_ D
K34 Net-_K19-Pad1_ Net-_D33-Pad2_ KEYSW
D33 Net-_D32-Pad1_ Net-_D33-Pad2_ D
K35 Net-_K20-Pad1_ Net-_D34-Pad2_ KEYSW
D34 Net-_D32-Pad1_ Net-_D34-Pad2_ D
K36 Net-_K21-Pad1_ Net-_D35-Pad2_ KEYSW
D35 Net-_D32-Pad1_ Net-_D35-Pad2_ D
K37 Net-_K22-Pad1_ Net-_D36-Pad2_ KEYSW
D36 Net-_D32-Pad1_ Net-_D36-Pad2_ D
K38 Net-_K23-Pad1_ Net-_D37-Pad2_ KEYSW
D37 Net-_D32-Pad1_ Net-_D37-Pad2_ D
K39 Net-_K24-Pad1_ Net-_D38-Pad2_ KEYSW
D38 Net-_D32-Pad1_ Net-_D38-Pad2_ D
K40 Net-_K25-Pad1_ Net-_D39-Pad2_ KEYSW
D39 Net-_D32-Pad1_ Net-_D39-Pad2_ D
K41 Net-_K10-Pad1_ Net-_D40-Pad2_ KEYSW
D40 Net-_D32-Pad1_ Net-_D40-Pad2_ D
K42 Net-_K11-Pad1_ Net-_D41-Pad2_ KEYSW
D41 Net-_D32-Pad1_ Net-_D41-Pad2_ D
K43 Net-_K12-Pad1_ Net-_D42-Pad2_ KEYSW
D42 Net-_D32-Pad1_ Net-_D42-Pad2_ D
K44 Net-_K14-Pad1_ Net-_D43-Pad2_ KEYSW
D43 Net-_D32-Pad1_ Net-_D43-Pad2_ D
K45 Net-_K15-Pad1_ Net-_D44-Pad2_ KEYSW
D44 Net-_D32-Pad1_ Net-_D44-Pad2_ D
K46 Net-_K16-Pad1_ Net-_D45-Pad2_ KEYSW
D45 Net-_D32-Pad1_ Net-_D45-Pad2_ D
K48 Net-_K19-Pad1_ Net-_D47-Pad2_ KEYSW
D47 Net-_D47-Pad1_ Net-_D47-Pad2_ D
K49 Net-_K20-Pad1_ Net-_D48-Pad2_ KEYSW
D48 Net-_D47-Pad1_ Net-_D48-Pad2_ D
K50 Net-_K21-Pad1_ Net-_D49-Pad2_ KEYSW
D49 Net-_D47-Pad1_ Net-_D49-Pad2_ D
K51 Net-_K22-Pad1_ Net-_D50-Pad2_ KEYSW
D50 Net-_D47-Pad1_ Net-_D50-Pad2_ D
K52 Net-_K23-Pad1_ Net-_D51-Pad2_ KEYSW
D51 Net-_D47-Pad1_ Net-_D51-Pad2_ D
K53 Net-_K24-Pad1_ Net-_D52-Pad2_ KEYSW
D52 Net-_D47-Pad1_ Net-_D52-Pad2_ D
K54 Net-_K25-Pad1_ Net-_D53-Pad2_ KEYSW
D53 Net-_D47-Pad1_ Net-_D53-Pad2_ D
K55 Net-_K10-Pad1_ Net-_D54-Pad2_ KEYSW
D54 Net-_D47-Pad1_ Net-_D54-Pad2_ D
K56 Net-_K11-Pad1_ Net-_D55-Pad2_ KEYSW
D55 Net-_D47-Pad1_ Net-_D55-Pad2_ D
K57 Net-_K12-Pad1_ Net-_D56-Pad2_ KEYSW
D56 Net-_D47-Pad1_ Net-_D56-Pad2_ D
K59 Net-_K14-Pad1_ Net-_D58-Pad2_ KEYSW
D58 Net-_D47-Pad1_ Net-_D58-Pad2_ D
K60 Net-_K15-Pad1_ Net-_D59-Pad2_ KEYSW
D59 Net-_D47-Pad1_ Net-_D59-Pad2_ D
K61 Net-_K16-Pad1_ Net-_D60-Pad2_ KEYSW
D60 Net-_D47-Pad1_ Net-_D60-Pad2_ D
K67 Net-_K19-Pad1_ Net-_D62-Pad2_ KEYSW
D62 Net-_D62-Pad1_ Net-_D62-Pad2_ D
K68 Net-_K21-Pad1_ Net-_D63-Pad2_ KEYSW
D63 Net-_D62-Pad1_ Net-_D63-Pad2_ D
K69 Net-_K23-Pad1_ Net-_D64-Pad2_ KEYSW
D64 Net-_D62-Pad1_ Net-_D64-Pad2_ D
K70 Net-_K24-Pad1_ Net-_D65-Pad2_ KEYSW
D65 Net-_D62-Pad1_ Net-_D65-Pad2_ D
K71 Net-_K10-Pad1_ Net-_D66-Pad2_ KEYSW
D66 Net-_D62-Pad1_ Net-_D66-Pad2_ D
K72 Net-_K12-Pad1_ Net-_D67-Pad2_ KEYSW
D67 Net-_D62-Pad1_ Net-_D67-Pad2_ D
K73 Net-_K14-Pad1_ Net-_D68-Pad2_ KEYSW
D68 Net-_D62-Pad1_ Net-_D68-Pad2_ D
K74 Net-_K16-Pad1_ Net-_D69-Pad2_ KEYSW
D69 Net-_D62-Pad1_ Net-_D69-Pad2_ D
K63 Net-_K12-Pad1_ Net-_D67-Pad2_ KEYSW
K58 Net-_K13-Pad1_ Net-_D57-Pad2_ KEYSW
D57 Net-_D47-Pad1_ Net-_D57-Pad2_ D
K47 NC_02 Net-_D46-Pad2_ KEYSW
D46 NC_03 Net-_D46-Pad2_ D
K66 Net-_K1-Pad1_ Net-_D61-Pad2_ KEYSW
D61 NC_04 Net-_D61-Pad2_ D
K17 Net-_K15-Pad1_ Net-_D15-Pad2_ KEYSW
K62 Net-_K15-Pad1_ Net-_D59-Pad2_ KEYSW
K64 Net-_K23-Pad1_ Net-_D64-Pad2_ KEYSW
K65 Net-_K24-Pad1_ Net-_D65-Pad2_ KEYSW
.end
