.title KiCad schematic
C102 Net-_C101-Pad1_ GND C_2.2uF
C101 Net-_C101-Pad1_ GND C_0.1uF
R103 Net-_COUT101-Pad1_ Net-_R102-Pad1_ R_100K
C103 Net-_C103-Pad1_ Net-_C103-Pad2_ C_0.1uF
COUT101 Net-_COUT101-Pad1_ GND C_22uF
COUT103 Net-_COUT101-Pad1_ GND C_47uF
COUT102 Net-_COUT101-Pad1_ GND C_33uF
R102 Net-_R102-Pad1_ GND R_25K
F101 Net-_C101-Pad1_ /12V F_500mA_16V
R104 Net-_COUT101-Pad1_ VCC R_0_2512
D103 GND Net-_D103-Pad2_ LED_0805
R105 VCC Net-_D103-Pad2_ R_200
D101 Net-_C101-Pad1_ GND D_Zener_18V
D102 GND Net-_D102-Pad2_ LED_0805
U2 Net-_R7-Pad2_ Net-_R8-Pad2_ Net-_R6-Pad2_ VCC GND /CAN_TX /CAN_RX /MISO /MOSI Net-_C5-Pad1_ Net-_C4-Pad1_ /SCK NC_01 NC_02 NC_03 /RTD_LSD NC_04 NC_05 Net-_C3-Pad1_ GND NC_06 NC_07 Net-_R4-Pad2_ Net-_R5-Pad2_ NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 /RESET NC_14 ATMEGA16M1
R1 VCC Net-_C3-Pad1_ R_100
C3 Net-_C3-Pad1_ GND C_100pF
Y1 Net-_C4-Pad1_ GND Net-_C5-Pad1_ GND Crystal_SMD
C4 Net-_C4-Pad1_ GND C_30pF
C5 Net-_C5-Pad1_ GND C_30pF
R3 VCC /RESET R_10K
U1 /CAN_TX GND VCC /CAN_RX NC_15 /CAN_LO /CAN_HI GND MCP2561-E_SN
C1 VCC GND C_0.1uF
R2 /CAN_HI /CAN_LO R_200
J1 /MISO VCC /SCK /MOSI /RESET GND CONN_02X03
C2 VCC GND C_0.1uF
U101 Net-_C103-Pad1_ GND Net-_R102-Pad1_ Net-_C101-Pad1_ Net-_C101-Pad1_ Net-_C103-Pad2_ TPS560430YF
R101 Net-_C101-Pad1_ Net-_D102-Pad2_ R_1K
L101 Net-_C103-Pad2_ Net-_COUT101-Pad1_ L_100uH
J3 GND /12V /12V /IS>BOTS_SS_INERTIA NC_16 NC_17 /ESTOP>HVD_SS_ESTOP GND NC_18 GND /CAN_HI /CAN_LO /CAN_LO /CAN_HI /CAN_GND NC_19 /STEERING_POT_SENSE NC_20 NC_21 GND /12V /12V GND NC_22 /THROTTLE_POT_1_SENSE NC_23 NC_24 /THROTTLE_POT_2_SENSE NC_25 /CAN_LO /CAN_HI /CAN_GND /RTD_LSD /CAN_HI /CAN_LO Ampseal_35_VT_HitL_Cockpit
J2 GND /12V /12V /IS>BOTS_SS_INERTIA NC_26 NC_27 /ESTOP>HVD_SS_ESTOP GND NC_28 GND /CAN_HI /CAN_LO /CAN_LO /CAN_HI /CAN_GND NC_29 NC_30 NC_31 NC_32 GND /12V /12V GND NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 /CAN_LO /CAN_HI /CAN_GND NC_39 /CAN_HI /CAN_LO Ampseal_35_VT_RKH_HitL_Cockpit
J4 GND /MOSI /MISO /SCK NC_40 GND SPI_NanoFit_RA_TH_06
D1 GND Net-_D1-Pad2_ LED
D2 GND Net-_D2-Pad2_ LED
R4 Net-_D1-Pad2_ Net-_R4-Pad2_ R_200
R5 Net-_D2-Pad2_ Net-_R5-Pad2_ R_200
R6 /STEERING_POT_SENSE Net-_R6-Pad2_ R_200
R7 /THROTTLE_POT_1_SENSE Net-_R7-Pad2_ R_200
R8 /THROTTLE_POT_2_SENSE Net-_R8-Pad2_ R_200
C6 /STEERING_POT_SENSE GND C_.22uF
C7 /THROTTLE_POT_1_SENSE GND C_.22uF
C8 /THROTTLE_POT_2_SENSE GND C_.22uF
.end
