.title KiCad schematic
J2 /Sheet5CB00087/LIN1 /Sheet5CB00087/LIN2 /Sheet5CB00087/LIN3 Conn_01x03
J1 /Sheet5CB00087/HIN1 /Sheet5CB00087/HIN2 /Sheet5CB00087/HIN3 Conn_01x03
R5 /Sheet5CB00087/BATT_VOLTAGE GNDREF 13K
R4 Net-_Q2-Pad3_ /Sheet5CB00087/BATT_VOLTAGE 150K
Q2 Net-_Q1-Pad1_ /Sheet5CB00087/V_BAT2+ Net-_Q2-Pad3_ IRF9530
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ GNDREF BC547
R2 /Sheet5CB00087/V_BAT2+ Net-_Q1-Pad1_ 10K
R1 Net-_Q1-Pad2_ /Sheet5CB00087/READ_CMD 10K
C5 /Sheet5CB00087/3V3 GNDREF C_Small
C4 /Sheet5CB00087/5V GNDREF C_Small
D1 GNDREF Net-_D1-Pad2_ LED
R6 /Sheet5CB00087/3V3 Net-_D1-Pad2_ R
U3 /Sheet5CB00087/3V3 GNDREF /Sheet5CB00087/5V LP2950-3.3_TO92
J6 /Sheet5CB00087/EXTIA /Sheet5CB00087/EXTIB /Sheet5CB00087/EXTIC Conn_01x03
C25 /Sheet5CB00087/EXTIC GNDREF C_Small
C23 /Sheet5CB00087/EXTIA GNDREF C_Small
C24 /Sheet5CB00087/EXTIB GNDREF C_Small
R30 /Sheet5CB00087/5V /Sheet5CB00087/EXTIC R
R29 /Sheet5CB00087/5V /Sheet5CB00087/EXTIB R
R28 /Sheet5CB00087/5V /Sheet5CB00087/EXTIA R
R27 /Sheet5CB00087/EXTIC Net-_R27-Pad2_ R
R25 /Sheet5CB00087/EXTIB Net-_R25-Pad2_ R
R26 /Sheet5CB00087/EXTIA Net-_R26-Pad2_ R
C19 /Sheet5CB00087/5V GNDREF 1
C18 /Sheet5CB00087/5V GNDREF 1
J4 /Sheet5CB00087/PHASE_A /Sheet5CB00087/PHASE_B /Sheet5CB00087/PHASE_C Conn_01x03
C27 /Sheet5CB00087/BEMF_C GNDREF C_Small
R32 /Sheet5CB00087/BEMF_C GNDREF R
R31 /Sheet5CB00087/PHASE_C /Sheet5CB00087/BEMF_C R
C22 /Sheet5CB00087/BEMF_B GNDREF C_Small
R24 /Sheet5CB00087/BEMF_B GNDREF R
R23 /Sheet5CB00087/PHASE_B /Sheet5CB00087/BEMF_B R
C21 /Sheet5CB00087/BEMF_A GNDREF C_Small
R22 /Sheet5CB00087/BEMF_A GNDREF R
R21 /Sheet5CB00087/PHASE_A /Sheet5CB00087/BEMF_A R
C20 /Sheet5CB00087/BEMF_REF GNDREF C_Small
R19 /Sheet5CB00087/BEMF_REF GNDREF R
R18 Net-_R16-Pad2_ /Sheet5CB00087/BEMF_REF R
R20 /Sheet5CB00087/PHASE_C Net-_R16-Pad2_ R
R17 /Sheet5CB00087/PHASE_B Net-_R16-Pad2_ R
R16 /Sheet5CB00087/PHASE_A Net-_R16-Pad2_ R
U8 Net-_R27-Pad2_ /Sheet5CB00087/BEMF_REF /Sheet5CB00087/BEMF_C GNDREF /Sheet5CB00087/5V LM393
U7 Net-_R26-Pad2_ /Sheet5CB00087/BEMF_REF /Sheet5CB00087/BEMF_A GNDREF /Sheet5CB00087/BEMF_B /Sheet5CB00087/BEMF_REF Net-_R25-Pad2_ /Sheet5CB00087/5V LM393
R3 /Sheet5CB00087/CURRENT_SENSOR Net-_R3-Pad2_ R
C3 /Sheet5CB00087/CURRENT_SENSOR GNDREF C_Small
0.1uF1 /Sheet5CB00087/3V3 GNDREF C_Small
U2 /Sheet5CB00087/3V3 GNDREF Net-_R3-Pad2_ GNDREF /Sheet5CB00087/CP ACS754
C2 /Sheet5CB00087/5V GNDREF 0.1uF
C1 NC_01 GNDREF CP1
U1 /Sheet5CB00087/12V_Bootstrap GNDREF /Sheet5CB00087/5V L7805
C8 /Sheet5CB00087/12V_Bootstrap GNDREF 10uF
C11 /Sheet5CB00087/12V_Bootstrap GNDREF 100nF
C6 /Sheet5CB00087/12V_Bootstrap GNDREF 10uF
C9 /Sheet5CB00087/12V_Bootstrap GNDREF 100nF
C7 /Sheet5CB00087/12V_Bootstrap GNDREF 10uF
C10 /Sheet5CB00087/12V_Bootstrap GNDREF 100nF
C14 /Sheet5CB00087/PHASE_C Net-_C14-Pad2_ 10uF
C12 /Sheet5CB00087/PHASE_B Net-_C12-Pad2_ 10uF
C13 /Sheet5CB00087/PHASE_A Net-_C13-Pad2_ 10uF
R14 Net-_D6-Pad2_ /Sheet5CB00087/CP 150k
R15 Net-_D8-Pad2_ /Sheet5CB00087/CP 150k
R13 Net-_D10-Pad2_ /Sheet5CB00087/CP 150k
C17 Net-_C14-Pad2_ /Sheet5CB00087/PHASE_C 100nF
D4 Net-_C14-Pad2_ /Sheet5CB00087/12V_Bootstrap 1N4148
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ 1N4148
D9 Net-_D9-Pad1_ Net-_D9-Pad2_ 1N4148
FQP85N6 /Sheet5CB00087/PHASE_C Net-_D10-Pad2_ /Sheet5CB00087/CP Q_NMOS_DGS
FQP85N5 /Sheet5CB00087/V_BAT2+ Net-_D9-Pad2_ /Sheet5CB00087/PHASE_C Q_NMOS_DGS
U6 /Sheet5CB00087/12V_Bootstrap /Sheet5CB00087/HIN3 /Sheet5CB00087/LIN3 GNDREF Net-_D10-Pad1_ /Sheet5CB00087/PHASE_C Net-_D9-Pad1_ Net-_C14-Pad2_ IR2101
R12 Net-_D10-Pad1_ Net-_D10-Pad2_ 22
R11 Net-_D9-Pad2_ Net-_D9-Pad1_ 22
C15 Net-_C12-Pad2_ /Sheet5CB00087/PHASE_B 100nF
D3 Net-_C12-Pad2_ /Sheet5CB00087/12V_Bootstrap 1N4148
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ 1N4148
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ 1N4148
FQP85N4 /Sheet5CB00087/PHASE_B Net-_D8-Pad2_ /Sheet5CB00087/CP Q_NMOS_DGS
FQP85N3 /Sheet5CB00087/V_BAT2+ Net-_D7-Pad2_ /Sheet5CB00087/PHASE_B Q_NMOS_DGS
U5 /Sheet5CB00087/12V_Bootstrap /Sheet5CB00087/HIN2 /Sheet5CB00087/LIN2 GNDREF Net-_D8-Pad1_ /Sheet5CB00087/PHASE_B Net-_D7-Pad1_ Net-_C12-Pad2_ IR2101
R10 Net-_D8-Pad1_ Net-_D8-Pad2_ 22
R9 Net-_D7-Pad2_ Net-_D7-Pad1_ 22
C16 Net-_C13-Pad2_ /Sheet5CB00087/PHASE_A 100nF
D2 Net-_C13-Pad2_ /Sheet5CB00087/12V_Bootstrap 1N4148
D6 Net-_D6-Pad1_ Net-_D6-Pad2_ 1N4148
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ 1N4148
FQP85N2 /Sheet5CB00087/PHASE_A Net-_D6-Pad2_ /Sheet5CB00087/CP Q_NMOS_DGS
FQP85N1 /Sheet5CB00087/V_BAT2+ Net-_D5-Pad2_ /Sheet5CB00087/PHASE_A Q_NMOS_DGS
U4 /Sheet5CB00087/12V_Bootstrap /Sheet5CB00087/HIN1 /Sheet5CB00087/LIN1 GNDREF Net-_D6-Pad1_ /Sheet5CB00087/PHASE_A Net-_D5-Pad1_ Net-_C13-Pad2_ IR2101
R8 Net-_D6-Pad1_ Net-_D6-Pad2_ 22
R7 Net-_D5-Pad2_ Net-_D5-Pad1_ 22
J3 /Sheet5CB00087/READ_CMD /Sheet5CB00087/CURRENT_SENSOR /Sheet5CB00087/BATT_VOLTAGE Conn_01x03
J5 /Sheet5CB00087/V_BAT+ GNDREF Conn_01x02
C26 /Sheet5CB00087/V_BAT+ GNDREF C
J7 /Sheet5CB00087/12V_Bootstrap GNDREF Conn_01x02
.end
