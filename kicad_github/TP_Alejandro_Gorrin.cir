.title KiCad schematic
R1 GNDD Net-_R1-Pad2_ 4.7K
R2 Net-_R2-Pad1_ Net-_CHG1-Pad1_ 1K
C3 GNDD +BATT 10uF
R10 Net-_D3-Pad2_ NC_01 1K
D3 GNDD Net-_D3-Pad2_ RED
D4 Net-_C6-Pad1_ VBUS MBR120
R12 VBUS GNDD 100K
C6 Net-_C6-Pad1_ GNDD 10uF
R7 Net-_C6-Pad1_ Net-_R7-Pad2_ 100K
U4 Net-_C6-Pad1_ GNDD Net-_R7-Pad2_ NC_02 +3V3 AP2112K-3.3
C7 +3V3 GNDD 10uF
C8 +3V3 GNDD 10uF
C1 +3V3 GNDD 10uF
R13 +3V3 /RESET 10K
C4 /RESET GNDD 1uF
C2 +3V3 GNDD 10uF
U3 NC_03 NC_04 Net-_U2-Pad7_ Net-_U2-Pad6_ +3V3 +3V3 +3V3 VBUS NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 /RTS /TXD0 /RXD0 NC_15 /DTR NC_16 NC_17 CP2104
U2 Net-_U2-Pad1_ Net-_U2-Pad1_ NC_18 NC_19 NC_20 Net-_U2-Pad6_ Net-_U2-Pad7_ GNDD VBUS VBUS NC_21 TPD4S014
R3 +BATT /A13_I35 100K
R4 /A13_I35 GNDD 100K
R13G1 Net-_Q2-Pad1_ /RTS 10K
R13G2 Net-_Q1-Pad1_ /DTR 10K
Q2 Net-_Q2-Pad1_ /DTR /GPIO0 MMBT3904
Q1 Net-_Q1-Pad1_ /RTS /RESET MMBT3904
U1 Net-_R2-Pad1_ GNDD +BATT VBUS Net-_R1-Pad2_ MCP73831-2-OT
CHG1 Net-_CHG1-Pad1_ VBUS ORANGE
Q3 +BATT VBUS Net-_C6-Pad1_ BS250
U5 GNDD /RESET /A4_IO36 /A3_I39 /A2_I34 /A13_I35 /IO32_A7 /IO33_A9 /A1_DAC1 /A0_DAC2 /IO27_A10 /IO14_A6 /IO12_A11 /IO13_A12 /IO15_A8 NC_22 NC_23 /GPIO0 /A5_IO4 /IO16 +3V3 /IO17 /SCK /MISI /SDA /MISO /SCI /RXD0 /TXD0 /IO21 NC_24 ESP3212
J1 +BATT NC_25 VBUS /IO13_A12 /IO12_A11 /IO27_A10 /IO33_A9 /IO15_A8 /IO32_A7 /IO14_A6 /SCI /SDA Conn_01x12
J3 /IO21 /IO17 /IO16 /MISO /MISI /SCK /A5_IO4 /A4_IO36 /A3_I39 /A2_I34 /A1_DAC1 /A0_DAC2 GNDD NC_26 +3V3 /RESET Conn_01x16
HS1 GNDD Heatsink_Pad
SW1 GNDD /RESET SW_1
J2 +BATT GNDD Conn_01x02
.end
