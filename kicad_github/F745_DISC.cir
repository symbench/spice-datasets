.title KiCad schematic
R1_BOOT1 GND Net-_BOOT1-Pad2_ 10k
C1_VCAP1 VCAP_1 GND 4.7u
C1_VCAP2 GND VCAP_2 4.7u
C7_ST1 GND BOOT 1u
C6_ST1 GND BOOT 100n
C5_ST1 GND BOOT 100n
C4_ST1 GND BOOT 100n
C3_ST1 GND BOOT 100n
C2_ST1 GND BOOT 100n
C1_ST1 GND BOOT 100n
R1_L1 GND Net-_D1-Pad1_ 330
D1 Net-_D1-Pad1_ 5V_IN LED
C2_VREG1 GND BOOT 10u
C1_VREG1 5V_IN GND 10u
Y1 OSC_IN GND OSC_OUT 16Mhz
U2 GND BOOT 5V_IN NCP1117-3.3_SOT223
U1 SCK1 PE3 NSS1 MISO1 MOSI1 BOOT LED PC14 PC15 GND BOOT OSC_IN OSC_OUT NRST PC0 PC1 PC2 PC3 GND BOOT BOOT PA0 PA1 PA2 PA3 GND BOOT NSS SCK MISO MOSI PC4 PC5 PB0 PB1 PB2 PE7 PE8 PE9 PE10 PE11 PE12 PE13 PE14 PE15 PB10 PB11 VCAP_1 GND BOOT PB12 PB13 PB14 PB15 PD8 PD9 PD10 PD11 PD12 PD13 PD14 PD15 PC6 PC7 PC8 PC9 PA8 TX RX USB_DM USB_DP SWDIO VCAP_2 GND BOOT SWCLK PA15 PC10 PC11 PC12 CAN_RX CAN_TX PD2 PD3 PD4 PD5 PD6 PD7 PB3 PB4 PB5 SCL SDA BOOT PB8 PB9 PE0 PE1 GND BOOT STM32F746VGTx
J2 GND NC_01 NC_02 5V_IN Net-_J2-PadA5_ Net-_J2-PadA6_ Net-_J2-PadA7_ NC_03 5V_IN NC_04 NC_05 GND GND NC_06 NC_07 5V_IN Net-_J2-PadB5_ Net-_J2-PadA6_ Net-_J2-PadA7_ NC_08 5V_IN NC_09 NC_10 GND GND USB_C_Receptacle
R1_USB1 GND Net-_J2-PadB5_ 5.1k
R1_USB3 GND Net-_J2-PadA5_ 5.1k
D3 TX Net-_D3-Pad2_ LED
D2 RX Net-_D2-Pad2_ LED
R1_RX1 Net-_D2-Pad2_ 5V_IN 330
R2_TX1 Net-_D3-Pad2_ 5V_IN 330
R1_SDA1 SDA BOOT 10k
R2_SCL1 BOOT SCL 10k
D4 GND Net-_D4-Pad2_ LED
R1_PC13 Net-_D4-Pad2_ LED 330
H2 GND MountingHole_Pad
H3 GND MountingHole_Pad
H1 GND MountingHole_Pad
H0 GND MountingHole_Pad
R1_USB2 Net-_J2-PadA6_ USB_DP 22
R2_USB1 Net-_J2-PadA7_ USB_DM 22
J1 NC_11 NSS1 MOSI1 BOOT SCK1 GND MISO1 NC_12 GND Micro_SD_Card
BOOT2 NRST Net-_BOOT2-Pad2_ SW_DIP_x01
R1_RST1 GND Net-_BOOT2-Pad2_ 10k
C7_ST2 GND BOOT 100n
D5 5V_IN GND GND CM1213A-01SO
BOOT1 BOOT Net-_BOOT1-Pad2_ SW_DIP_x01
J9 SDA SCL Conn_01x02
J8 CAN_TX CAN_RX Conn_01x02
J7 NSS SCK MISO MOSI Conn_01x04
J6 SWDIO SWCLK BOOT GND Conn_01x04
J5 TX RX 5V_IN GND Conn_01x04
J3 PB8 PB9 PB5 PB4 PB3 PD7 PD6 PD5 PD4 PD3 PD2 PC12 PC11 PC10 PA15 PA8 PC8 PC9 PC6 PC7 PD14 PD15 PD12 PD13 PD10 PD11 PD8 PD9 PB14 PB15 PB12 PB13 Conn_02x16_Odd_Even
J4 PE1 PE0 PC14 PE3 PC0 PC15 PC2 PC1 PA0 PC3 PA2 PA1 PC4 PA3 PB0 PC5 PB2 PB1 PE8 PE7 PE10 PE9 PE12 PE11 PE14 PE13 PB10 PE15 5V_IN PB11 BOOT GND Conn_02x16_Odd_Even
.end
