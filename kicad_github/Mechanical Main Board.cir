.title KiCad schematic
D38 +3.3V Net-_D38-Pad2_ LED
R52 GND Net-_D38-Pad2_ 220
D36 +5V Net-_D36-Pad2_ LED
R50 GND Net-_D36-Pad2_ 680
R51 GND Net-_D37-Pad2_ 330
D37 +5VD Net-_D37-Pad2_ LED
D35 +12V Net-_D35-Pad2_ LED
R49 GND Net-_D35-Pad2_ 820
R48 GND Net-_D34-Pad2_ 1K
D34 +15V Net-_D34-Pad2_ LED x 5
P38 /codeurs-moteurs/RST /PIC30F4013-3/RSTC CAVALIER
P37 /codeurs-moteurs/RST /PIC30F4013-2/RSTB CAVALIER
P36 /codeurs-moteurs/RST /PIC30F4013-1/RSTA CAVALIER x3
P35 GND +5VD /PIC30F4013-1/SCL /PIC30F4013-1/SDA CONN_4
P34 GND +5VD /PIC30F4013-1/SCL /PIC30F4013-1/SDA CONN_4
P32 GND +5VD /PIC30F4013-1/SCL /PIC30F4013-1/SDA CONN_4
P33 GND +5VD /PIC30F4013-1/SCL /PIC30F4013-1/SDA CONN_4
P12 GND +3.3V +5VD +5V +12V +15V CONN_6
P7 GND +3.3V +5VD +5V +12V +15V CONN_6
P11 GND +3.3V +5VD +5V +12V +15V CONN_6
P13 /codeurs-moteurs/M5A /codeurs-moteurs/M5B /codeurs-moteurs/M6A /codeurs-moteurs/M6B CONN_4
P9 /codeurs-moteurs/M3A /codeurs-moteurs/M3B /codeurs-moteurs/M4A /codeurs-moteurs/M4B CONN_4
P8 /codeurs-moteurs/M1A /codeurs-moteurs/M1B /codeurs-moteurs/M2A /codeurs-moteurs/M2B CONN_4
P6 /codeurs-moteurs/SERV1 /codeurs-moteurs/SERV2 /codeurs-moteurs/SERV3 /codeurs-moteurs/SERV4 /codeurs-moteurs/SERV5 /codeurs-moteurs/SERV6 CONN_6
P5 /codeurs-moteurs/IO0 /codeurs-moteurs/IO1 /codeurs-moteurs/IO2 /codeurs-moteurs/IO3 /codeurs-moteurs/IO4 /codeurs-moteurs/IO5 /codeurs-moteurs/IO6 /codeurs-moteurs/IO7 CONN_8
P3 GND +5VD /PIC30F4013-1/SCL /PIC30F4013-1/SDA CONN_4
P4 GND /codeurs-moteurs/TX +5VD /codeurs-moteurs/RX CONN_4
P2 GND GND /PIC30F4013-1/SDA /PIC30F4013-1/SCL /codeurs-moteurs/RX /codeurs-moteurs/TX NC_01 NC_02 /codeurs-moteurs/IO0 /codeurs-moteurs/IO1 /codeurs-moteurs/IO2 /codeurs-moteurs/IO3 /codeurs-moteurs/IO4 /codeurs-moteurs/IO5 /codeurs-moteurs/IO6 /codeurs-moteurs/IO7 /PIC30F4013-1/IRQ0 /PIC30F4013-2/IRQ1 GND /PIC30F4013-3/IRQ2 /codeurs-moteurs/SERV1 GND /codeurs-moteurs/SERV2 GND /codeurs-moteurs/SERV3 GND /codeurs-moteurs/SERV4 /codeurs-moteurs/RST /codeurs-moteurs/SERV5 GND /codeurs-moteurs/SERV6 NC_03 /codeurs-moteurs/A1 /codeurs-moteurs/A2 /codeurs-moteurs/B1 /codeurs-moteurs/B2 /codeurs-moteurs/Z1 /codeurs-moteurs/Z2 GND GND HE10-40
P10 /codeurs-moteurs/A1 /codeurs-moteurs/B1 /codeurs-moteurs/Z1 /codeurs-moteurs/A2 /codeurs-moteurs/B2 /codeurs-moteurs/Z2 GND +12V CONN_8
P1 /codeurs-moteurs/M1A /codeurs-moteurs/M1B /codeurs-moteurs/M2A /codeurs-moteurs/M2B /codeurs-moteurs/M3A /codeurs-moteurs/M3B /codeurs-moteurs/M4A /codeurs-moteurs/M4B /codeurs-moteurs/M5A /codeurs-moteurs/M5B /codeurs-moteurs/M6A /codeurs-moteurs/M6B CONN_12
P42 GND /PIC30F4013-3/TXC +5VD /PIC30F4013-3/RXC CONN_4
C18 +5VD GND 100n
C17 +5VD GND 100n
C16 +5VD GND 100n
C15 +5V GND 100n
K62 GND +12V Net-_D33-Pad1_ CONN_3
K61 GND +12V Net-_D32-Pad1_ CONN_3
K60 GND +12V Net-_D31-Pad1_ CONN_3
K59 GND +12V Net-_D30-Pad1_ CONN_3
K58 GND +12V Net-_D29-Pad1_ CONN_3
K48 GND +5V /PIC30F4013-3/AN13 CONN_3
K51 GND +5V /PIC30F4013-3/AN16 CONN_3
K52 GND +5V /PIC30F4013-3/AN17 CONN_3
K50 GND +5V /PIC30F4013-3/AN15 CONN_3
K47 GND +5V /PIC30F4013-3/AN12 CONN_3
K49 GND +5V /PIC30F4013-3/AN14 CONN_3
K53 Net-_K53-Pad1_ Net-_K53-Pad2_ CONN_2
K63 /PIC30F4013-3/C3RX /PIC30F4013-3/C3TX CONN_2
K56 GND +5V /PIC30F4013-3/PWM11 CONN_3
K57 GND +5V /PIC30F4013-3/PWM12 CONN_3
K55 GND +5V /PIC30F4013-3/PWM10 CONN_3
K54 GND +5V /PIC30F4013-3/PWM9 CONN_3
D33 Net-_D33-Pad1_ Net-_D33-Pad2_ LED
D32 Net-_D32-Pad1_ Net-_D32-Pad2_ LED
D31 Net-_D31-Pad1_ Net-_D31-Pad2_ LED
D30 Net-_D30-Pad1_ Net-_D30-Pad2_ LED
D29 Net-_D29-Pad1_ Net-_D29-Pad2_ LED x 5
R47 /PIC30F4013-3/L15 GND 470
R45 /PIC30F4013-3/L13 GND 470
R43 /PIC30F4013-3/L11 GND 470
R44 /PIC30F4013-3/L12 GND 470
R46 /PIC30F4013-3/L14 GND 470
R42 Net-_D33-Pad2_ /PIC30F4013-3/L15 470
R41 Net-_D32-Pad2_ /PIC30F4013-3/L14 470
R40 Net-_D31-Pad2_ /PIC30F4013-3/L13 470
R39 Net-_D30-Pad2_ /PIC30F4013-3/L12 470
R38 Net-_D29-Pad2_ /PIC30F4013-3/L11 470
J3 /PIC30F4013-3/RSTC +5VD GND /PIC30F4013-3/PGDC /PIC30F4013-3/PGCC NC_04 NC_05 NC_06 RJ12
C6 Net-_C6-Pad1_ GND 22p
C5 Net-_C5-Pad1_ GND 22p
X3 Net-_C5-Pad1_ Net-_C6-Pad1_ 7.3725Mhz
K46 GND Net-_K46-Pad2_ CONN_2
R37 /PIC30F4013-3/RSTC Net-_K46-Pad2_ 15
R36 +5VD /PIC30F4013-3/RSTC 10k
U3 /PIC30F4013-3/RSTC /PIC30F4013-3/AN12 /PIC30F4013-3/AN13 /PIC30F4013-3/AN14 /PIC30F4013-3/AN15 /PIC30F4013-3/AN16 /PIC30F4013-3/AN17 /PIC30F4013-3/PGCC /PIC30F4013-3/PGDC /PIC30F4013-3/L11 +5VD GND Net-_C6-Pad1_ Net-_C5-Pad1_ Net-_K53-Pad1_ Net-_K53-Pad2_ /PIC30F4013-3/IRQ2 /PIC30F4013-3/R8 /PIC30F4013-3/PWM12 GND +5VD /PIC30F4013-3/PWM11 /PIC30F4013-3/R7 NC_07 /PIC30F4013-1/SCL /PIC30F4013-1/SDA /PIC30F4013-3/TXC /PIC30F4013-3/RXC /PIC30F4013-3/C3TX /PIC30F4013-3/C3RX GND +5VD /PIC30F4013-3/PWM10 /PIC30F4013-3/PWM9 /PIC30F4013-3/L15 /PIC30F4013-3/L14 /PIC30F4013-3/L13 /PIC30F4013-3/L12 GND +5V DSPIC30F4013
P44 GND /PIC30F4013-2/TXB +5VD /PIC30F4013-2/RXB CONN_4
C14 +5VD GND 100n
C13 +5VD GND 100n
C12 +5VD GND 100n
C11 +5V GND 100n
K44 GND +12V Net-_D28-Pad1_ CONN_3
K43 GND +12V Net-_D27-Pad1_ CONN_3
K42 GND +12V Net-_D26-Pad1_ CONN_3
K41 GND +12V Net-_D25-Pad1_ CONN_3
K40 GND +12V Net-_D24-Pad1_ CONN_3
K30 GND +5V /PIC30F4013-2/AN7 CONN_3
K33 GND +5V /PIC30F4013-2/AN10 CONN_3
K34 GND +5V /PIC30F4013-2/AN11 CONN_3
K32 GND +5V /PIC30F4013-2/AN9 CONN_3
K29 GND +5V /PIC30F4013-2/AN6 CONN_3
K31 GND +5V /PIC30F4013-2/AN8 CONN_3
K35 Net-_K35-Pad1_ Net-_K35-Pad2_ CONN_2
K45 /PIC30F4013-2/C2RX /PIC30F4013-2/C2TX CONN_2
K38 GND +5V /PIC30F4013-2/PWM7 CONN_3
K39 GND +5V /PIC30F4013-2/PWM8 CONN_3
K37 GND +5V /PIC30F4013-2/PWM6 CONN_3
K36 GND +5V /PIC30F4013-2/PWM5 CONN_3
D28 Net-_D28-Pad1_ Net-_D28-Pad2_ LED
D27 Net-_D27-Pad1_ Net-_D27-Pad2_ LED
D26 Net-_D26-Pad1_ Net-_D26-Pad2_ LED
D25 Net-_D25-Pad1_ Net-_D25-Pad2_ LED
D24 Net-_D24-Pad1_ Net-_D24-Pad2_ LED x 5
R35 /PIC30F4013-2/L10 GND 470
R33 /PIC30F4013-2/L8 GND 470
R31 /PIC30F4013-2/L6 GND 470
R32 /PIC30F4013-2/L7 GND 470
R34 /PIC30F4013-2/L9 GND 470
R30 Net-_D28-Pad2_ /PIC30F4013-2/L10 470
R29 Net-_D27-Pad2_ /PIC30F4013-2/L9 470
R28 Net-_D26-Pad2_ /PIC30F4013-2/L8 470
R27 Net-_D25-Pad2_ /PIC30F4013-2/L7 470
R26 Net-_D24-Pad2_ /PIC30F4013-2/L6 470
J2 /PIC30F4013-2/RSTB +5VD GND /PIC30F4013-2/PGDB /PIC30F4013-2/PGCB NC_08 NC_09 NC_10 RJ12
C4 Net-_C4-Pad1_ GND 22p
C3 Net-_C3-Pad1_ GND 22p
X2 Net-_C3-Pad1_ Net-_C4-Pad1_ 7.3728 Mhz
K28 GND Net-_K28-Pad2_ CONN_2
R25 /PIC30F4013-2/RSTB Net-_K28-Pad2_ 15
R24 +5VD /PIC30F4013-2/RSTB 10k
U2 /PIC30F4013-2/RSTB /PIC30F4013-2/AN6 /PIC30F4013-2/AN7 /PIC30F4013-2/AN8 /PIC30F4013-2/AN9 /PIC30F4013-2/AN10 /PIC30F4013-2/AN11 /PIC30F4013-2/PGCB /PIC30F4013-2/PGDB /PIC30F4013-2/L6 +5VD GND Net-_C4-Pad1_ Net-_C3-Pad1_ Net-_K35-Pad1_ Net-_K35-Pad2_ /PIC30F4013-2/IRQ1 /PIC30F4013-2/R5 /PIC30F4013-2/PWM8 GND +5VD /PIC30F4013-2/PWM7 /PIC30F4013-2/R4 NC_11 /PIC30F4013-1/SCL /PIC30F4013-1/SDA /PIC30F4013-2/TXB /PIC30F4013-2/RXB /PIC30F4013-2/C2TX /PIC30F4013-2/C2RX GND +5VD /PIC30F4013-2/PWM6 /PIC30F4013-2/PWM5 /PIC30F4013-2/L10 /PIC30F4013-2/L9 /PIC30F4013-2/L8 /PIC30F4013-2/L7 GND +5V DSPIC30F4013
P43 +5VD /PIC30F4013-1/TXA GND /PIC30F4013-1/RXA CONN_4
C10 +5VD GND 100n
C9 +5VD GND 100n
C8 +5VD GND 100n
C7 +5V GND 100n
K26 GND +12V Net-_D23-Pad1_ CONN_3
K25 GND +12V Net-_D22-Pad1_ CONN_3
K24 GND +12V Net-_D21-Pad1_ CONN_3
K23 GND +12V Net-_D20-Pad1_ CONN_3
K22 GND +12V Net-_D19-Pad1_ CONN_3
K12 GND +5V /PIC30F4013-1/AN1A CONN_3
K15 GND +5V /PIC30F4013-1/AN4A CONN_3
K16 GND +5V /PIC30F4013-1/AN5A CONN_3
K14 GND +5V /PIC30F4013-1/AN3A CONN_3
K11 GND +5V /PIC30F4013-1/AN0A CONN_3
K13 GND +5V /PIC30F4013-1/AN2A CONN_3
K17 Net-_K17-Pad1_ Net-_K17-Pad2_ CONN_2
K27 /PIC30F4013-1/C1RX /PIC30F4013-1/C1TX CONN_2
K20 GND +5V /PIC30F4013-1/PWM3 CONN_3
K21 GND +5V /PIC30F4013-1/PWM4 CONN_3
K19 GND +5V /PIC30F4013-1/PWM2 CONN_3
K18 GND +5V /PIC30F4013-1/PWM1 CONN_3
D23 Net-_D23-Pad1_ Net-_D23-Pad2_ LED
D22 Net-_D22-Pad1_ Net-_D22-Pad2_ LED
D21 Net-_D21-Pad1_ Net-_D21-Pad2_ LED
D20 Net-_D20-Pad1_ Net-_D20-Pad2_ LED
D19 Net-_D19-Pad1_ Net-_D19-Pad2_ LED
R23 /PIC30F4013-1/L5 GND 470
R21 /PIC30F4013-1/L3 GND 470
R19 /PIC30F4013-1/L1 GND 470
R20 /PIC30F4013-1/L2 GND 470
R22 /PIC30F4013-1/L4 GND 470
R18 Net-_D23-Pad2_ /PIC30F4013-1/L5 470
R17 Net-_D22-Pad2_ /PIC30F4013-1/L4 470
R16 Net-_D21-Pad2_ /PIC30F4013-1/L3 470
R15 Net-_D20-Pad2_ /PIC30F4013-1/L2 470
R14 Net-_D19-Pad2_ /PIC30F4013-1/L1 470
P41 /PIC30F4013-1/SDA Net-_P41-Pad2_ CAVALIER
P40 /PIC30F4013-1/SCL Net-_P40-Pad2_ CAVALIER
R13 +5VD Net-_P41-Pad2_ R
R12 +5VD Net-_P40-Pad2_ R
J1 /PIC30F4013-1/RSTA +5VD GND /PIC30F4013-1/PGDA /PIC30F4013-1/PGCA NC_12 NC_13 NC_14 RJ12
C2 Net-_C2-Pad1_ GND 22p
C1 Net-_C1-Pad1_ GND 22p
X1 Net-_C1-Pad1_ Net-_C2-Pad1_ 7.3728 Mhz
K10 GND Net-_K10-Pad2_ CONN_2
R11 /PIC30F4013-1/RSTA Net-_K10-Pad2_ 15
R10 +5VD /PIC30F4013-1/RSTA 10k
U1 /PIC30F4013-1/RSTA /PIC30F4013-1/AN0A /PIC30F4013-1/AN1A /PIC30F4013-1/AN2A /PIC30F4013-1/AN3A /PIC30F4013-1/AN4A /PIC30F4013-1/AN5A /PIC30F4013-1/PGCA /PIC30F4013-1/PGDA /PIC30F4013-1/L1 +5VD GND Net-_C2-Pad1_ Net-_C1-Pad1_ Net-_K17-Pad1_ Net-_K17-Pad2_ /PIC30F4013-1/IRQ0 /PIC30F4013-1/R2 /PIC30F4013-1/PWM4 GND +5VD /PIC30F4013-1/PWM3 /PIC30F4013-1/R1 NC_15 /PIC30F4013-1/SCL /PIC30F4013-1/SDA /PIC30F4013-1/TXA /PIC30F4013-1/RXA /PIC30F4013-1/C1TX /PIC30F4013-1/C1RX GND +5VD /PIC30F4013-1/PWM2 /PIC30F4013-1/PWM1 /PIC30F4013-1/L5 /PIC30F4013-1/L4 /PIC30F4013-1/L3 /PIC30F4013-1/L2 GND +5V DSPIC30F4013
K7 Net-_D13-Pad1_ /Relais Encodeurs/9A Net-_K7-Pad6_ Net-_K7-Pad8_ Net-_K7-Pad9_ Net-_K7-Pad11_ /Relais Encodeurs/10A +12V RELAY_A_2RT
D14 +12V Net-_D14-Pad2_ LED
SW6 Net-_D15-Pad1_ GND SW_PUSH_SMALL
SW5 Net-_D13-Pad1_ GND SW_PUSH_SMALL
SW4 Net-_D9-Pad1_ GND SW_PUSH_SMALL
SW3 Net-_D7-Pad1_ GND SW_PUSH_SMALL
SW2 Net-_D3-Pad1_ GND SW_PUSH_SMALL
SW1 Net-_D1-Pad1_ GND SW_PUSH_SMALL
R4 Net-_D8-Pad2_ Net-_D7-Pad1_ 820
Q8 GND /PIC30F4013-3/R8 Net-_D15-Pad1_ BSS123
Q7 GND /PIC30F4013-3/R7 Net-_D13-Pad1_ BSS123
Q4 GND /PIC30F4013-2/R4 Net-_D7-Pad1_ BSS123
Q5 GND /PIC30F4013-2/R5 Net-_D9-Pad1_ BSS123
Q2 GND /PIC30F4013-1/R2 Net-_D3-Pad1_ BSS123
R2 Net-_D4-Pad2_ Net-_D3-Pad1_ 820
D1 Net-_D1-Pad1_ +12V DIODE
Q1 GND /PIC30F4013-1/R1 Net-_D1-Pad1_ BSS123
P31 /Relais Encodeurs/11A Net-_K8-Pad11_ +12V CAVALIER2
P30 /Relais Encodeurs/10C Net-_K7-Pad9_ GND CAVALIER2
P26 /Relais Encodeurs/10B Net-_K7-Pad11_ /Relais Encodeurs/11C CAVALIER2
P29 /Relais Encodeurs/9C Net-_K7-Pad8_ /Relais Encodeurs/11C CAVALIER2
P27 /Relais Encodeurs/9B Net-_K7-Pad6_ GND CAVALIER2
P24 /Relais Encodeurs/7A Net-_K5-Pad11_ +12V CAVALIER2
P23 /Relais Encodeurs/6C Net-_K4-Pad9_ GND CAVALIER2
P21 /Relais Encodeurs/6B Net-_K4-Pad11_ /Relais Encodeurs/7C CAVALIER2
P22 /Relais Encodeurs/5C Net-_K4-Pad8_ /Relais Encodeurs/7C CAVALIER2
P20 /Relais Encodeurs/5B Net-_K4-Pad6_ GND CAVALIER2
P17 /Relais Encodeurs/1C Net-_K1-Pad8_ /Relais Encodeurs/3C CAVALIER2
P14 /Relais Encodeurs/1B Net-_K1-Pad6_ GND CAVALIER2
P19 /Relais Encodeurs/3A Net-_K2-Pad11_ +12V CAVALIER2
P16 /Relais Encodeurs/2C Net-_K1-Pad9_ GND CAVALIER2
P15 /Relais Encodeurs/2B Net-_K1-Pad11_ /Relais Encodeurs/3C CAVALIER2
P28 /Relais Encodeurs/11C /Relais Encodeurs/11A /Relais Encodeurs/11B /Relais Encodeurs/10C /Relais Encodeurs/10A /Relais Encodeurs/10B /Relais Encodeurs/9C /Relais Encodeurs/9A /Relais Encodeurs/9B CONN_9
K8 Net-_K8-Pad11_ /Relais Encodeurs/11B /Relais Encodeurs/11C +12V Net-_D15-Pad1_ RELAY_1RT_FINDER
P25 /Relais Encodeurs/7C /Relais Encodeurs/7A /Relais Encodeurs/7B /Relais Encodeurs/6C /Relais Encodeurs/6A /Relais Encodeurs/6B /Relais Encodeurs/5C /Relais Encodeurs/5A /Relais Encodeurs/5B CONN_9
P18 /Relais Encodeurs/3C /Relais Encodeurs/3A /Relais Encodeurs/3B /Relais Encodeurs/2C /Relais Encodeurs/2A /Relais Encodeurs/2B /Relais Encodeurs/1C /Relais Encodeurs/1A /Relais Encodeurs/1B CONN_9
K5 Net-_K5-Pad11_ /Relais Encodeurs/7B /Relais Encodeurs/7C +12V Net-_D9-Pad1_ RELAY_1RT_FINDER
D10 +12V Net-_D10-Pad2_ LED
R5 Net-_D10-Pad2_ Net-_D9-Pad1_ 820
D9 Net-_D9-Pad1_ +12V DIODE
D16 +12V Net-_D16-Pad2_ LED
R8 Net-_D16-Pad2_ Net-_D15-Pad1_ 820
D15 Net-_D15-Pad1_ +12V DIODE
D13 Net-_D13-Pad1_ +12V DIODE
R7 Net-_D14-Pad2_ Net-_D13-Pad1_ 820
D7 Net-_D7-Pad1_ +12V DIODE
D8 +12V Net-_D8-Pad2_ LED
K4 Net-_D7-Pad1_ /Relais Encodeurs/5A Net-_K4-Pad6_ Net-_K4-Pad8_ Net-_K4-Pad9_ Net-_K4-Pad11_ /Relais Encodeurs/6A +12V RELAY_A_2RT
K2 Net-_K2-Pad11_ /Relais Encodeurs/3B /Relais Encodeurs/3C +12V Net-_D3-Pad1_ RELAY_1RT_FINDER
D4 +12V Net-_D4-Pad2_ LED
D3 Net-_D3-Pad1_ +12V DIODE
R1 Net-_D2-Pad2_ Net-_D1-Pad1_ 820
D2 +12V Net-_D2-Pad2_ LED
K1 Net-_D1-Pad1_ /Relais Encodeurs/1A Net-_K1-Pad6_ Net-_K1-Pad8_ Net-_K1-Pad9_ Net-_K1-Pad11_ /Relais Encodeurs/2A +12V RELAY_A_2RT
.end
