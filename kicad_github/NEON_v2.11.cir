.title KiCad schematic
H1 GND MH_P
H2 GND MH_P
H3 GND MH_P
H4 GND MH_P
LOGO1 Logo_Open_Hardware_Small
LOGO2 Logo_Open_Hardware_Small
Y1 Net-_C18-Pad1_ Net-_C19-Pad1_ Crystal
C18 Net-_C18-Pad1_ GND 20pF
C21 GND +3V3 100nF
C20 NRST GND 100nF
R23 +3V3 NRST 10k
R21 Net-_J1-Pad2_ BOOT_1 10k
R22 Net-_J24-Pad2_ BOOT_0 10k
J2 5V_USB Net-_J2-Pad2_ Net-_J2-Pad3_ NC_01 GND GND USB_B_Micro
J24 +3V3 Net-_J24-Pad2_ GND B_0_SEL
J1 +3V3 Net-_J1-Pad2_ GND B_1_SEL
J25 +3V3 SWDIO SWDCLK GND ST-LINK
C15 GND +3V3 100nF
R32 Net-_J2-Pad2_ USB- 10R
R31 Net-_J2-Pad3_ USB+ 10R
R30 +3V3 USB+ 1.5K
C19 Net-_C19-Pad1_ GND 20pF
C22 GND +3V3 100nF
C23 GND +3V3 100nF
C24 GND +3V3 100nF
C25 GND +3V3 100nF
SW1 NRST GND SW_Push
J15 NRST GND Conn_01x02
U4 NC_02 Z_2_DIR E_EN E_STEP Net-_C18-Pad1_ Net-_C19-Pad1_ NRST Z_2_STEP Z_2_EN E_DIR NC_03 GND +3V3 FAN_2 Z_DIR STM_TX_2 STM_RX_2 GND +3V3 Temp_1 SCK_2 MISO_2 MOSI_2 Temp_0 SDCS FAN_0 FAN_1 BOOT_1 PB10 PB11 GND +3V3 PB12 PB13 X_Min Y_Min Z_Min X_DIR X_STEP Heatbed Hotend STM_TX_1 STM_RX_1 USB- USB+ SWDIO GND +3V3 SWDCLK Servo_0 STM_TX_4 STM_RX_4 X_EN Servo_1 Y_EN Y_STEP Y_DIR SCL SDA BOOT_0 Z_EN Z_STEP GND +3V3 STM32F103RE
J3 Net-_A1-Pad3_ Net-_A1-Pad4_ Net-_A1-Pad5_ Net-_A1-Pad6_ X_MOT
JP1 +3V3 Net-_A1-Pad12_ SJ
JP2 +3V3 Net-_A1-Pad11_ SJ
JP3 +3V3 Net-_A1-Pad10_ SJ
JP4 +3V3 Net-_A2-Pad12_ SJ
JP5 +3V3 Net-_A2-Pad11_ SJ
JP6 +3V3 Net-_A2-Pad10_ SJ
C1 +12V GND 100uF
C2 +12V GND 100uF
C3 +12V GND 100uF
C4 +12V GND 100uF
C5 +12V GND 100uF
A1 GND +3V3 Net-_A1-Pad3_ Net-_A1-Pad4_ Net-_A1-Pad5_ Net-_A1-Pad6_ GND +12V X_EN Net-_A1-Pad10_ Net-_A1-Pad11_ Net-_A1-Pad12_ Net-_A1-Pad13_ Net-_A1-Pad13_ X_STEP X_DIR Pololu_Breakout_A4988
A2 GND +3V3 Net-_A2-Pad3_ Net-_A2-Pad4_ Net-_A2-Pad5_ Net-_A2-Pad6_ GND +12V Y_EN Net-_A2-Pad10_ Net-_A2-Pad11_ Net-_A2-Pad12_ Net-_A2-Pad13_ Net-_A2-Pad13_ Y_STEP Y_DIR Pololu_Breakout_A4988
J4 Net-_A2-Pad3_ Net-_A2-Pad4_ Net-_A2-Pad5_ Net-_A2-Pad6_ Y_MOT
J5 Net-_A3-Pad3_ Net-_A3-Pad4_ Net-_A3-Pad5_ Net-_A3-Pad6_ Z_MOT_A
JP7 +3V3 Net-_A3-Pad12_ SJ
JP8 +3V3 Net-_A3-Pad11_ SJ
JP9 +3V3 Net-_A3-Pad10_ SJ
J7 Net-_A5-Pad3_ Net-_A5-Pad4_ Net-_A5-Pad5_ Net-_A5-Pad6_ E_MOT
JP10 +3V3 Net-_A4-Pad12_ SJ
JP11 +3V3 Net-_A4-Pad11_ SJ
JP12 +3V3 Net-_A4-Pad10_ SJ
J6 Net-_A4-Pad3_ Net-_A4-Pad4_ Net-_A4-Pad5_ Net-_A4-Pad6_ Z_MOT_B
JP13 +3V3 Net-_A5-Pad12_ SJ
JP14 +3V3 Net-_A5-Pad11_ SJ
JP15 +3V3 Net-_A5-Pad10_ SJ
A3 GND +3V3 Net-_A3-Pad3_ Net-_A3-Pad4_ Net-_A3-Pad5_ Net-_A3-Pad6_ GND +12V Z_EN Net-_A3-Pad10_ Net-_A3-Pad11_ Net-_A3-Pad12_ Net-_A3-Pad13_ Net-_A3-Pad13_ Z_STEP Z_DIR Pololu_Breakout_A4988
A4 GND +3V3 Net-_A4-Pad3_ Net-_A4-Pad4_ Net-_A4-Pad5_ Net-_A4-Pad6_ GND +12V Z_2_EN Net-_A4-Pad10_ Net-_A4-Pad11_ Net-_A4-Pad12_ Net-_A4-Pad13_ Net-_A4-Pad13_ Z_2_STEP Z_2_DIR Pololu_Breakout_A4988
A5 GND +3V3 Net-_A5-Pad3_ Net-_A5-Pad4_ Net-_A5-Pad5_ Net-_A5-Pad6_ GND +12V E_EN Net-_A5-Pad10_ Net-_A5-Pad11_ Net-_A5-Pad12_ Net-_A5-Pad13_ Net-_A5-Pad13_ E_STEP E_DIR Pololu_Breakout_A4988
R15 GND Net-_Q5-Pad1_ 10k
R12 GND Net-_Q4-Pad1_ 10k
R9 GND Net-_Q3-Pad1_ 10k
R6 GND Net-_Q2-Pad1_ 10k
R3 GND Net-_Q1-Pad1_ 10k
D1 +12V /MOSFET/Hotend_OUT SS54
Q2 Net-_Q2-Pad1_ /MOSFET/Heatbed_OUT GND IRLR8743
Q1 Net-_Q1-Pad1_ /MOSFET/Hotend_OUT GND IRLR8743
J12 +12V /MOSFET/FAN_2_OUT FAN_2_OUT
D9 GND Net-_D9-Pad2_ LED_RED
D6 GND Net-_D6-Pad2_ LED_RED
J11 +12V /MOSFET/FAN_1_OUT FAN_1_OUT
D8 GND Net-_D8-Pad2_ LED_RED
R1 Net-_D5-Pad2_ Hotend_Buff 330
D5 GND Net-_D5-Pad2_ LED_RED
J10 +12V /MOSFET/FAN_0_OUT FAN_0_OUT
D7 GND Net-_D7-Pad2_ LED_RED
Q3 Net-_Q3-Pad1_ GND /MOSFET/FAN_0_OUT AO3400A
D15 +12V /MOSFET/FAN_0_OUT SS14
R4 Net-_D6-Pad2_ Heatbed_Buff 330
R2 Net-_Q1-Pad1_ Hotend_Buff 150R
R5 Net-_Q2-Pad1_ Heatbed_Buff 150R
R8 Net-_Q3-Pad1_ FAN_0 150R
R11 Net-_Q4-Pad1_ FAN_1 150R
R14 Net-_Q5-Pad1_ FAN_2 150R
R7 Net-_D7-Pad2_ FAN_0 150R
R10 Net-_D8-Pad2_ FAN_1 150R
R13 Net-_D9-Pad2_ FAN_2 150R
Q4 Net-_Q4-Pad1_ GND /MOSFET/FAN_1_OUT AO3400A
Q5 Net-_Q5-Pad1_ GND /MOSFET/FAN_2_OUT AO3400A
D2 V_Bed /MOSFET/Heatbed_OUT SS54
D16 +12V /MOSFET/FAN_1_OUT SS14
D17 +12V /MOSFET/FAN_2_OUT SS14
J8 +12V /MOSFET/Hotend_OUT Hotend_OUT
J9 V_Bed /MOSFET/Heatbed_OUT Heatbed_OUT
C6 +12V GND 100nF
F1 /Power/12V_In +12V Fuse
D3 +12V GND SS54
F2 /Power/V_Bed_In V_Bed Fuse
C10 +5V GND 100nF
C9 +12V GND 100nF
U2 GND +3V3 +5V AP1117-33
C12 +3V3 GND 100nF
C11 +5V GND 100nF
R19 GND Net-_D13-Pad1_ 330
R20 GND Net-_D14-Pad1_ 150R
R17 GND Net-_D11-Pad1_ 1k
R16 GND Net-_D10-Pad1_ 1k
D10 Net-_D10-Pad1_ +12V LED_RED
J21 +3V3 GND +3V3 GND +5V GND +5V GND +12V GND +12V GND Conn_02x06_Odd_Even
U1 Net-_C17-Pad2_ NC_04 NC_05 Net-_R18-Pad1_ NC_06 GND +12V /Power/BuckOut GND TPS5430
L1 /Power/BuckOut +5V 10uH
C17 /Power/BuckOut Net-_C17-Pad2_ 10nF
R18 Net-_R18-Pad1_ +5V 10k
R33 GND Net-_R18-Pad1_ 3.3k
D11 Net-_D11-Pad1_ V_Bed LED_RED
D13 Net-_D13-Pad1_ +5V LED_RED
D14 Net-_D14-Pad1_ +3V3 LED_RED
C7 +12V GND 100uF
C8 +12V GND 100uF
D12 /Power/BuckOut GND SS54
D4 +5V 5V_USB SS54
C26 +5V GND 100uF
J13 GND /Power/12V_In +12V_IN
J14 GND /Power/V_Bed_In V_Heatbed_IN
R28 +3V3 Temp_0 4K7
R29 +3V3 Temp_1 4k7
J17 +5V GND X_Min Endstop_X
C14 Temp_1 GND 10uF
C13 Temp_0 GND 10uF
R24 GND Hotend 10k
R25 GND Heatbed 10k
J23 GND +5V Servo_0_Buff Servo_0
J20 +3V3 GND SDA SCL I2C
J26 +3V3 GND MISO_2 MOSI_2 SCK_2 SDCS SPI
J33 Temp_1 GND TEMP_1
J32 Temp_0 GND TEMP_0
J22 GND +5V Servo_1_Buff Servo_1
J18 +5V GND Y_Min Endstop_Y
J19 +5V GND Z_Min Endstop_Z
C16 +5V GND 100nF
J16 +3V3 +3V3 GND GND STM_RX_1 STM_RX_4 STM_TX_1 STM_TX_4 Serial_1_2
J27 +3V3 +3V3 GND GND PB10 PB11 PB12 PB13 Serial_3_4
D18 GND Net-_D18-Pad2_ LED_RED
R34 Net-_D18-Pad2_ PB12 150R
D19 GND Net-_D19-Pad2_ LED_RED
R35 Net-_D19-Pad2_ PB13 150R
J28 NC_07 Net-_J28-Pad2_ GND GPIO0_SEL
R26 +3V3 SCL 4k7
R27 +3V3 SDA 4k7
J29 NC_08 SDCS MOSI_2 +3V3 SCK_2 GND MISO_2 NC_09 NC_10 GND Micro_SD_Card_Det
U3 GND Heatbed Heatbed_Buff GND Hotend Hotend_Buff GND Servo_1_Buff Servo_1 GND Servo_0_Buff Servo_0 GND +5V 74HCT125
J30 GND STM_RX_2 NC_11 +3V3 Net-_J28-Pad2_ NC_12 STM_TX_2 +3V3 ESP-01v090
.end
