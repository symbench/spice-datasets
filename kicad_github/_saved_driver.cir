.title KiCad schematic
CON1 Power_12V_+ GND GND BARREL_JACK
J3 5V 5V 5V Net-_J3-Padb1_ Net-_J3-Padb2_ Net-_J3-Padb3_ m_Driver_2
J1 3.3V 5V SDA1_I2C_GPIO02 5V SCL1_I2C_GPIO03 GND GPIO04 TX_GPIO14 GND RX_GPIO15 GPIO17 GPIO18 GPIO27 GND GPIO22 GPIO23 3.3V GPIO24 GPIO10_SPI_MOSI GND GPIO09_SPI_MISO GPIO25 GPIO11_SPI_CLK SPI_CE0_GPIO08 GND SPI_CE0_GPIO07 ID_SD_EEPROM I2C_ID_SC_EEPROM GPIO05 GND GPIO06 GPIO12 GPIO13 GND GPIO19 GPIO16 GPIO26 GPIO20 GND GPIO21 Raspberry_Pi_Pin_Out_1
J17 Power_12V_+ GND header_board_2
C1 Power_12V_+ GND 470uf
J8 Net-_J5-Pad11_ Net-_J5-Pad9_ Net-_J5-Pad7_ Net-_J5-Pad5_ Conn_01x04
J5 GND GPIO20 5V GPIO21 Net-_J5-Pad5_ Net-_J5-Pad6_ Net-_J5-Pad7_ Net-_J5-Pad6_ Net-_J5-Pad9_ Net-_J3-Padb3_ Net-_J5-Pad11_ Net-_J3-Padb2_ GND Net-_J3-Padb1_ Power_12V_+ GPIO06 Driver_2
J4 5V 5V 5V Net-_J4-Padb1_ Net-_J4-Padb2_ Net-_J4-Padb3_ m_Driver_1
C2 Power_12V_+ GND 470uf
J9 Net-_J7-Pad11_ Net-_J7-Pad9_ Net-_J7-Pad7_ Net-_J7-Pad5_ Conn_01x04
J7 GND GPIO16 5V GPIO12 Net-_J7-Pad5_ Net-_J7-Pad6_ Net-_J7-Pad7_ Net-_J7-Pad6_ Net-_J7-Pad9_ Net-_J4-Padb3_ Net-_J7-Pad11_ Net-_J4-Padb2_ GND Net-_J4-Padb1_ Power_12V_+ GPIO05 Driver_1
J11 5V 5V 5V Net-_J11-Padb1_ Net-_J11-Padb2_ Net-_J11-Padb3_ m_Driver_3
C3 Power_12V_+ GND 470uf
J15 Net-_J13-Pad11_ Net-_J13-Pad9_ Net-_J13-Pad7_ Net-_J13-Pad5_ Conn_01x04
J13 GND GPIO24 5V GPIO23 Net-_J13-Pad5_ Net-_J13-Pad6_ Net-_J13-Pad7_ Net-_J13-Pad6_ Net-_J13-Pad9_ Net-_J11-Padb3_ Net-_J13-Pad11_ Net-_J11-Padb2_ GND Net-_J11-Padb1_ Power_12V_+ GPIO18 Driver_3
J12 5V 5V 5V Net-_J12-Padb1_ Net-_J12-Padb2_ Net-_J12-Padb3_ m_Driver_4
C4 Power_12V_+ GND 470uf
J16 Net-_J14-Pad11_ Net-_J14-Pad9_ Net-_J14-Pad7_ Net-_J14-Pad5_ Conn_01x04
J14 GND GPIO22 5V GPIO27 Net-_J14-Pad5_ Net-_J14-Pad6_ Net-_J14-Pad7_ Net-_J14-Pad6_ Net-_J14-Pad9_ Net-_J12-Padb3_ Net-_J14-Pad11_ Net-_J12-Padb2_ GND Net-_J12-Padb1_ Power_12V_+ GPIO17 Driver_4
J2 3.3V 5V SDA1_I2C_GPIO02 5V SCL1_I2C_GPIO03 GND GPIO04 TX_GPIO14 GND RX_GPIO15 GPIO17 GPIO18 GPIO27 GND GPIO22 GPIO23 3.3V GPIO24 GPIO10_SPI_MOSI GND GPIO09_SPI_MISO GPIO25 GPIO11_SPI_CLK SPI_CE0_GPIO08 GND SPI_CE0_GPIO07 ID_SD_EEPROM I2C_ID_SC_EEPROM GPIO05 GND GPIO06 GPIO12 GPIO13 GND GPIO19 GPIO16 GPIO26 GPIO20 GND GPIO21 Raspberry_Pi_Pin_Out_2
J6 Power_12V_+ GND to_board_2
U1 Power_12V_+ Power_12V_+ GND GND 5V 5V GND GND MP1584
D3 Net-_D3-Pad1_ Power_12V_+ LED
R3 Net-_D3-Pad1_ GND R
D2 Net-_D2-Pad1_ 5V LED
R2 Net-_D2-Pad1_ GND R
J10 Power_12V_+ GND header_board_1
D1 Net-_D1-Pad1_ Power_12V_+ LED
R1 Net-_D1-Pad1_ GND R
.end
