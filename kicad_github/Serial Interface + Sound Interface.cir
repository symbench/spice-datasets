.title KiCad schematic
UG12 /D_24_ /D_25_ /D_27_ /D_29_ /D_31_ NC_01 PU PU SCCWREQ* NC_02 SYNC3M RXDA CTSA* TXOA DTRA* RTSA* CTSA* DCDA* C3M DCDB* CTSB* RTSB* DRTB* TXDB CTSB* RXDB C3M NC_03 SCCWREQ* /A_2_ NC_04 /A_1_ NC_05 NC_06 /D_30_ /D_28_ /D_26_ NC_07 8530
UD12 NC_08 TXOA RTSA* Net-_UD12-Pad5_ Net-_UD12-Pad5_ RTSB* TXDB NC_09 NC_10 /TXDB+ /TXDB- NC_11 NC_12 /TXDA- /TXDA+ NC_13 26LS30
UE12 NC_14 DTRA* Net-_UE12-Pad4_ Net-_UE12-Pad4_ Net-_UE12-Pad4_ Net-_UE12-Pad4_ DRTB* NC_15 NC_16 NC_17 /HSKDB NC_18 NC_19 /HSKDA NC_20 NC_21 26LS30
UB12 Net-_UB12-Pad1_ Net-_UB12-Pad1_ NC_22 NC_23 SYNC3M Net-_UB12-Pad1_ /GPIA /GPIA /HSKIA CTSA* PU DCDA* Net-_UB12-Pad1_ 75175
UC12 /RXDA- /RXDA+ RXDA PU RXDB /RXDA+ /RXDB- Net-_UC12-Pad14_ /HSKIB CTSB* PU DCDB* Net-_UC12-Pad14_ 75175
UB11 Net-_UB10-Pad1_ /SV0 /SV1 /SV2 RESET* NC_24 NC_25 Net-_UB11-Pad8_ Net-_UB11-Pad8_ NC_26 /+12V-SND /+12V-SND NC_27 NC_28 /VREF /PWMA SONY SND
UB10 Net-_UB10-Pad1_ /SV0 /SV1 /SV2 NC_29 NC_30 NC_31 Net-_UB10-Pad8_ Net-_UB10-Pad8_ NC_32 /+12V-SND /+12V-SND NC_33 NC_34 /VREF /PWMB SONY SND
L2 NC_35 NC_36 NC_37 /AND-L-AC /SND-R-AC Net-_J1-Pad1_ CMC
RP2 NC_38 /HSKIAF /RXDAF- /RXDAF+ /GPIAF NC_39 /TXDAF+ /TXDAF- /HSXDAF Net-_J2-Pad~_ Net-_RP2-Pad11_ /HSKDA /TXDA- /TXDA+ NC_40 /GPIA /RXDA+ /RXDA- /HSKIA Net-_RP2-Pad11_ RCNET
RP3 NC_41 /HSKIBF /RXDBF- /RXDBF+ /GPIBF NC_42 /TCDBF+ /TXDBF- /HSKDBF Net-_J3-Pad~_ Net-_RP3-Pad11_ /HSKDB /TXDB- /TXDB+ NC_43 /GPIB /RXDA+ /RXDB- /HSKIB Net-_RP3-Pad11_ RCNET
J2 /HSXDAF SERIAL_CONN
J3 /TCDBF+ SERIAL_CONN
UE10 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 /D_31_ /D_30_ /D_29_ /D_28_ /D_27_ /D_26_ /D_25_ /D_24_ NC_56 NC_57 NC_58 NC_59 /PWMB /PWMA /SV0 /SV1 /SV2 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 RESET* NC_66 /A_1_ /A_2_ NC_67 DSC
Q1 SND-M1 SND-M2 Net-_Q1-Pad3_ 2N3904
UA9 NC_68 NC_69 NC_70 Net-_Q2-Pad3_ NC_71 SND-M1 Net-_Q1-Pad3_ NC_72 TL071
Q2 SND-M1 SND-M2 Net-_Q2-Pad3_ 2N3906
J1 Net-_J1-Pad1_ /AND-L-AC Net-_J1-Pad10_ /SND-R-AC Net-_J1-Pad14_ Net-_J1-Pad1_ Net-_J1-Pad1_ /AND-L-AC /AND-L-AC Net-_J1-Pad10_ Net-_J1-Pad10_ /SND-R-AC /SND-R-AC Net-_J1-Pad14_ Net-_J1-Pad14_ Phone Jack
.end
