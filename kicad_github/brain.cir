.title KiCad schematic
R1 /MC/INT_POS_5V GND 10K
J3 /MC/INT_POS_5V +5V Keyboard
J1 GND NC_01 /STEP_PULSE_D /INT_CLOCK_D /EXT_CLOCK_D /OUTPUT_F /OUTPUT_E /OUTPUT_D /OFFSET_D /OUTPUT_C /OFFSET_C /OUTPUT_B /OFFSET_B /OUTPUT_A /OFFSET_A GND TOP
J2 GND NC_02 NC_03 /SEQ_RESET_D /SEQ_ZERO_D /SEQ_DIR_D +5V GND BOTTOM
H1 GND M3
H2 GND M3
H3 GND M3
H4 GND M3
J8 /EXT_POS_A /PULSELEN_A /EXT_RATE_A GND RIGHT
J4 +5V +5V +12V +12V GND GND GND GND GND GND -12V -12V Filtered Power
U2 /MC/RST /INT_CLOCK_D /STEP_PULSE_D /EXT_CLOCK_D /SEQ_RESET_D /OUTPUTS/LATCH Net-_C16-Pad2_ GND /MC/XTAL1 /MC/XTAL2 /OUTPUTS/SERIAL /OUTPUTS/SHIFT /SEQ_DIR_D /SEQ_ZERO_D NC_04 NC_05 /MC/D11-MOSI /MC/D12-MISO /MC/D13-SCK Net-_C17-Pad2_ +5V GND /MC/EXT_POS_5V /Analog Inputs/RATE_5V /MC/INT_POS_5V /Analog Inputs/PULSE_LENGTH_5V NC_06 NC_07 ATmega328P-PU
J5 /MC/D11-MOSI +5V NC_08 GND /MC/RST GND /MC/D13-SCK GND /MC/D12-MISO GND ICSP
Y1 /MC/XTAL1 /MC/XTAL2 Crystal
C15 /MC/XTAL2 GND 22pF
C14 /MC/XTAL1 GND 22pF
C17 GND Net-_C17-Pad2_ 100nF
FB1 +5V Net-_C16-Pad2_ Ferrite_Bead
FB2 Net-_C16-Pad2_ Net-_C17-Pad2_ Ferrite_Bead
C16 GND Net-_C16-Pad2_ 15pF
SW1 GND Net-_R40-Pad2_ RST
R40 /MC/RST Net-_R40-Pad2_ 330
R41 /MC/RST +5V 10K
C18 /MC/RST GND 100nF
D7 +5V /MC/RST 1N4148
U3 Net-_R11-Pad2_ /EXT_RATE_A GND +12V GND Net-_R11-Pad1_ Net-_R4-Pad2_ Net-_R5-Pad2_ Net-_R10-Pad1_ GND -12V GND /EXT_POS_A Net-_R10-Pad2_ TL074
R13 Net-_R11-Pad2_ /EXT_RATE_A 100K
R11 Net-_R11-Pad1_ Net-_R11-Pad2_ 100K
R7 Net-_R4-Pad2_ Net-_R11-Pad1_ 100K
R4 /Analog Inputs/RATE_5V Net-_R4-Pad2_ 1K
D1 +5V /Analog Inputs/RATE_5V S
D2 /Analog Inputs/RATE_5V GND S
R14 Net-_R10-Pad2_ /EXT_POS_A 100K
R10 Net-_R10-Pad1_ Net-_R10-Pad2_ 100K
R8 Net-_R5-Pad2_ Net-_R10-Pad1_ 100K
R5 /MC/EXT_POS_5V Net-_R5-Pad2_ 1K
D3 +5V /MC/EXT_POS_5V S
D4 /MC/EXT_POS_5V GND S
C4 GND -12V .1uF
C5 GND +12V .1uF
U4 Net-_R12-Pad2_ /PULSELEN_A GND -12V GND Net-_R12-Pad1_ Net-_R6-Pad2_ +12V TL072
R15 Net-_R12-Pad2_ /PULSELEN_A 100K
R12 Net-_R12-Pad1_ Net-_R12-Pad2_ 100K
R9 Net-_R6-Pad2_ Net-_R12-Pad1_ 100K
R6 /Analog Inputs/PULSE_LENGTH_5V Net-_R6-Pad2_ 1K
D5 +5V /Analog Inputs/PULSE_LENGTH_5V S
D6 /Analog Inputs/PULSE_LENGTH_5V GND S
C6 GND -12V .1uF
C7 GND +12V .1uF
U5 Net-_J6-Pad3_ Net-_J6-Pad4_ Net-_J6-Pad5_ Net-_J6-Pad6_ Net-_J6-Pad7_ Net-_J6-Pad8_ Net-_J6-Pad9_ GND Net-_U5-Pad9_ +5V /OUTPUTS/SHIFT /OUTPUTS/LATCH GND /OUTPUTS/SERIAL Net-_J6-Pad2_ +5V 74HC595
U6 Net-_J6-Pad11_ Net-_J6-Pad12_ Net-_J6-Pad13_ Net-_J6-Pad14_ Net-_J6-Pad15_ Net-_J6-Pad16_ Net-_J6-Pad17_ GND NC_09 +5V /OUTPUTS/SHIFT /OUTPUTS/LATCH GND Net-_U5-Pad9_ Net-_J6-Pad10_ +5V 74HC595
C8 +5V GND 10uF
C9 +5V GND 10uF
J6 GND Net-_J6-Pad2_ Net-_J6-Pad3_ Net-_J6-Pad4_ Net-_J6-Pad5_ Net-_J6-Pad6_ Net-_J6-Pad7_ Net-_J6-Pad8_ Net-_J6-Pad9_ Net-_J6-Pad10_ Net-_J6-Pad11_ Net-_J6-Pad12_ Net-_J6-Pad13_ Net-_J6-Pad14_ Net-_J6-Pad15_ Net-_J6-Pad16_ Net-_J6-Pad17_ TO_OUTPUTS
U7 Net-_R26-Pad2_ Net-_R28-Pad2_ GND +12V GND Net-_R20-Pad2_ Net-_R16-Pad2_ Net-_R24-Pad2_ Net-_R29-Pad2_ GND -12V GND Net-_R22-Pad2_ Net-_R17-Pad2_ TL074
R28 Net-_R26-Pad2_ Net-_R28-Pad2_ 100K
R26 Net-_R20-Pad2_ Net-_R26-Pad2_ 100K
R20 Net-_R16-Pad2_ Net-_R20-Pad2_ 100K
R29 Net-_R24-Pad2_ Net-_R29-Pad2_ 100K
R24 Net-_R22-Pad2_ Net-_R24-Pad2_ 100K
R22 Net-_R17-Pad2_ Net-_R22-Pad2_ 100K
U8 Net-_R27-Pad2_ Net-_R30-Pad2_ GND +12V GND Net-_R21-Pad2_ Net-_R18-Pad2_ Net-_R25-Pad2_ Net-_R31-Pad2_ GND -12V GND Net-_R23-Pad2_ Net-_R19-Pad2_ TL074
C12 GND -12V .1uF
C13 GND +12V .1uF
R32 Net-_R28-Pad2_ Net-_J7-Pad1_ 100K
R33 Net-_R28-Pad2_ /OFFSET_A 100K
R34 Net-_R29-Pad2_ Net-_J7-Pad2_ 100K
R35 Net-_R29-Pad2_ /OFFSET_B 100K
R16 /OUTPUT_A Net-_R16-Pad2_ 1K
R17 /OUTPUT_B Net-_R17-Pad2_ 1K
R30 Net-_R27-Pad2_ Net-_R30-Pad2_ 100K
R27 Net-_R21-Pad2_ Net-_R27-Pad2_ 100K
R21 Net-_R18-Pad2_ Net-_R21-Pad2_ 100K
R31 Net-_R25-Pad2_ Net-_R31-Pad2_ 100K
R25 Net-_R23-Pad2_ Net-_R25-Pad2_ 100K
R23 Net-_R19-Pad2_ Net-_R23-Pad2_ 100K
R36 Net-_R30-Pad2_ Net-_J7-Pad3_ 100K
R37 Net-_R30-Pad2_ /OFFSET_C 100K
R38 Net-_R31-Pad2_ Net-_J7-Pad4_ 100K
R39 Net-_R31-Pad2_ /OFFSET_D 100K
R18 /OUTPUT_C Net-_R18-Pad2_ 1K
R19 /OUTPUT_D Net-_R19-Pad2_ 1K
C10 GND -12V .1uF
C11 GND +12V .1uF
J7 Net-_J7-Pad1_ Net-_J7-Pad2_ Net-_J7-Pad3_ Net-_J7-Pad4_ /OUTPUT_E /OUTPUT_F FROM_OUTPUTS
.end
