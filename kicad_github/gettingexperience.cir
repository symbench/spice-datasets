.title KiCad schematic
USB1 GND VCC NC_01 Net-_R_CC1-Pad2_ USB_D- USB_D+ USB_D- USB_D+ NC_02 Net-_R_CC2-Pad2_ VCC GND NC_03 HRO-TYPE-C-31-M-12
R_CC1 GND Net-_R_CC1-Pad2_ 5.1k
R_CC2 GND Net-_R_CC2-Pad2_ 5.1k
U2 USB_D- GND USB_D+ USB_D- VCC USB_D+ SRV05-4
F1 VCC +5V 500ma
D_PWR1 +5V GND SMF9.0CA
U1 GND +3V3 +5V MCP1700-3302E_SOT23
R_LDO1 +5V GND 100k
C_LDO1 +5V GND 1u
R_LDO2 +3V3 GND 100k
C_LDO2 +3V3 GND 1u
D_LDO1 +5V +3V3 RB060MM-60TR
C_VDD3 +3V3 GND 100n
C_VDD1 +3V3 GND 100n
C_VDD2 +3V3 GND 100n
C_VDD5 +3V3 GND 4.7u
C_VDDA1 +3V3 GND 10u
C_VDDA2 +3V3 GND 1u
SW1 NRST GND SW_Push
R_BOOT1 Net-_BOOT1-Pad2_ BOOT0 10k
BOOT1 +3V3 Net-_BOOT1-Pad2_ GND SW_SPDT
Y1 XTAL_IN XTAL_OUT 8MHz
C_XTAL1 XTAL_OUT GND 30pF
C_XTAL2 XTAL_IN GND 30pF
JSWD1 +3V3 SWDIO GND SWCLK GND NC_04 NC_05 NC_06 GND NRST Conn_02x05_Odd_Even
RGB3 +5V Net-_RGB3-Pad2_ GND Net-_RGB2-Pad2_ WS2812B
RGB4 +5V Net-_RGB4-Pad2_ GND Net-_RGB3-Pad2_ WS2812B
RGB2 +5V Net-_RGB2-Pad2_ GND Net-_RGB1-Pad2_ WS2812B
RGB5 +5V Net-_RGB5-Pad2_ GND Net-_RGB4-Pad2_ WS2812B
RGB6 +5V Net-_RGB6-Pad2_ GND Net-_RGB5-Pad2_ WS2812B
RGB1 +5V Net-_RGB1-Pad2_ GND RGB WS2812B
RGB7 +5V Net-_RGB7-Pad2_ GND Net-_RGB6-Pad2_ WS2812B
RGB8 +5V NC_07 GND Net-_RGB7-Pad2_ WS2812B
C1 +5V GND 0.1uF
C2 +5V GND 0.1uF
C3 +5V GND 0.1uF
C4 +5V GND 0.1uF
C5 +5V GND 0.1uF
C6 +5V GND 0.1uF
C7 +5V GND 0.1uF
C8 +5V GND 0.1uF
MX1 COL0 Net-_D1-Pad2_ MX-NoLED
R_STAT1 LEDSTAT1 Net-_D_LEDSTAT1-Pad2_ 200ohms
D_LEDSTAT1 GND Net-_D_LEDSTAT1-Pad2_ LED
R_STAT2 LEDSTAT2 Net-_D_LEDSTAT2-Pad2_ 200ohms
D_LEDSTAT2 GND Net-_D_LEDSTAT2-Pad2_ LED
R_STAT3 LEDSTAT3 Net-_D_LEDSTAT3-Pad2_ 200ohms
D_LEDSTAT3 GND Net-_D_LEDSTAT3-Pad2_ LED
D1 ROW0 Net-_D1-Pad2_ D_Small
MX2 COL1 Net-_D2-Pad2_ MX-NoLED
D2 ROW0 Net-_D2-Pad2_ D_Small
MX3 COL2 Net-_D3-Pad2_ MX-NoLED
D3 ROW0 Net-_D3-Pad2_ D_Small
MX4 COL3 Net-_D4-Pad2_ MX-NoLED
D4 ROW0 Net-_D4-Pad2_ D_Small
MX5 COL4 Net-_D5-Pad2_ MX-NoLED
D5 ROW0 Net-_D5-Pad2_ D_Small
MX6 COL5 Net-_D6-Pad2_ MX-NoLED
D6 ROW0 Net-_D6-Pad2_ D_Small
MX7 COL6 Net-_D7-Pad2_ MX-NoLED
D7 ROW0 Net-_D7-Pad2_ D_Small
MX8 ALTCOL Net-_D8-Pad2_ MX-NoLED
D8 ROW0 Net-_D8-Pad2_ D_Small
MX9 COL8 Net-_D9-Pad2_ MX-NoLED
D9 ROW0 Net-_D9-Pad2_ D_Small
MX10 625SPCCOL Net-_D10-Pad2_ MX-NoLED
D10 ROW0 Net-_D10-Pad2_ D_Small
MX11 COL10 Net-_D11-Pad2_ MX-NoLED
D11 ROW0 Net-_D11-Pad2_ D_Small
MX12 COL11 Net-_D12-Pad2_ MX-NoLED
D12 ROW0 Net-_D12-Pad2_ D_Small
MX13 COL12 Net-_D13-Pad2_ MX-NoLED
D13 ROW0 Net-_D13-Pad2_ D_Small
MX14 COL13 Net-_D14-Pad2_ MX-NoLED
D14 ROW0 Net-_D14-Pad2_ D_Small
MX15 COL14 Net-_D15-Pad2_ MX-NoLED
D15 ROW0 Net-_D15-Pad2_ D_Small
MX16 COL15 Net-_D16-Pad2_ MX-NoLED
D16 ROW0 Net-_D16-Pad2_ D_Small
MX17 COL16 Net-_D17-Pad2_ MX-NoLED
D17 ROW0 Net-_D17-Pad2_ D_Small
MX18 COL17 Net-_D18-Pad2_ MX-NoLED
D18 ROW0 Net-_D18-Pad2_ D_Small
MX19 COL0 Net-_D19-Pad2_ MX-NoLED
D19 ROW1 Net-_D19-Pad2_ D_Small
MX20 COL1 Net-_D20-Pad2_ MX-NoLED
D20 ROW1 Net-_D20-Pad2_ D_Small
MX21 COL2 Net-_D21-Pad2_ MX-NoLED
D21 ROW1 Net-_D21-Pad2_ D_Small
MX22 COL3 Net-_D22-Pad2_ MX-NoLED
D22 ROW1 Net-_D22-Pad2_ D_Small
MX23 COL4 ENC1ROW MX-NoLED
D23 ROW1 ENC1ROW D_Small
MX24 COL5 Net-_D24-Pad2_ MX-NoLED
D24 ROW1 Net-_D24-Pad2_ D_Small
MX25 COL6 Net-_D25-Pad2_ MX-NoLED
D25 ROW1 Net-_D25-Pad2_ D_Small
MX26 ALTCOL Net-_D26-Pad2_ MX-NoLED
D26 ROW1 Net-_D26-Pad2_ D_Small
MX27 COL8 Net-_D27-Pad2_ MX-NoLED
D27 ROW1 Net-_D27-Pad2_ D_Small
MX28 625SPCCOL Net-_D28-Pad2_ MX-NoLED
D28 ROW1 Net-_D28-Pad2_ D_Small
MX29 COL10 Net-_D29-Pad2_ MX-NoLED
D29 ROW1 Net-_D29-Pad2_ D_Small
MX30 COL11 Net-_D30-Pad2_ MX-NoLED
D30 ROW1 Net-_D30-Pad2_ D_Small
MX31 COL12 Net-_D31-Pad2_ MX-NoLED
D31 ROW1 Net-_D31-Pad2_ D_Small
MX32 COL13 Net-_D32-Pad2_ MX-NoLED
D32 ROW1 Net-_D32-Pad2_ D_Small
MX33 COL14 Net-_D33-Pad2_ MX-NoLED
D33 ROW1 Net-_D33-Pad2_ D_Small
MX34 COL15 Net-_D34-Pad2_ MX-NoLED
D34 ROW1 Net-_D34-Pad2_ D_Small
MX35 COL16 Net-_D35-Pad2_ MX-NoLED
D35 ROW1 Net-_D35-Pad2_ D_Small
MX36 COL17 Net-_D36-Pad2_ MX-NoLED
D36 ROW1 Net-_D36-Pad2_ D_Small
MX37 COL18 Net-_D37-Pad2_ MX-NoLED
D37 ROW1 Net-_D37-Pad2_ D_Small
MX39 COL0 Net-_D38-Pad2_ MX-NoLED
D38 ROW2 Net-_D38-Pad2_ D_Small
MX40 COL1 Net-_D39-Pad2_ MX-NoLED
D39 ROW2 Net-_D39-Pad2_ D_Small
MX41 COL2 Net-_D40-Pad2_ MX-NoLED
D40 ROW2 Net-_D40-Pad2_ D_Small
MX42 COL3 NP+ROW MX-NoLED
D41 ROW2 NP+ROW D_Small
MX43 COL4 ENC2ROW MX-NoLED
D42 ROW2 ENC2ROW D_Small
MX44 COL5 Net-_D43-Pad2_ MX-NoLED
D43 ROW2 Net-_D43-Pad2_ D_Small
MX45 COL6 Net-_D44-Pad2_ MX-NoLED
D44 ROW2 Net-_D44-Pad2_ D_Small
MX46 ALTCOL Net-_D45-Pad2_ MX-NoLED
D45 ROW2 Net-_D45-Pad2_ D_Small
MX47 COL8 Net-_D46-Pad2_ MX-NoLED
D46 ROW2 Net-_D46-Pad2_ D_Small
MX48 625SPCCOL Net-_D47-Pad2_ MX-NoLED
D47 ROW2 Net-_D47-Pad2_ D_Small
MX49 COL10 Net-_D48-Pad2_ MX-NoLED
D48 ROW2 Net-_D48-Pad2_ D_Small
MX50 COL11 Net-_D49-Pad2_ MX-NoLED
D49 ROW2 Net-_D49-Pad2_ D_Small
MX51 COL12 Net-_D50-Pad2_ MX-NoLED
D50 ROW2 Net-_D50-Pad2_ D_Small
MX52 COL13 Net-_D51-Pad2_ MX-NoLED
D51 ROW2 Net-_D51-Pad2_ D_Small
MX53 COL14 Net-_D52-Pad2_ MX-NoLED
D52 ROW2 Net-_D52-Pad2_ D_Small
MX54 COL15 Net-_D53-Pad2_ MX-NoLED
D53 ROW2 Net-_D53-Pad2_ D_Small
MX55 COL16 Net-_D54-Pad2_ MX-NoLED
D54 ROW2 Net-_D54-Pad2_ D_Small
MX56 COL17 Net-_D55-Pad2_ MX-NoLED
D55 ROW2 Net-_D55-Pad2_ D_Small
MX59 COL0 Net-_D57-Pad2_ MX-NoLED
D57 ROW3 Net-_D57-Pad2_ D_Small
MX60 COL1 Net-_D58-Pad2_ MX-NoLED
D58 ROW3 Net-_D58-Pad2_ D_Small
MX61 COL2 Net-_D59-Pad2_ MX-NoLED
D59 ROW3 Net-_D59-Pad2_ D_Small
MX62 COL3 Net-_D60-Pad2_ MX-NoLED
D60 ROW3 Net-_D60-Pad2_ D_Small
MX63 COL4 ENC3ROW MX-NoLED
D61 ROW3 ENC3ROW D_Small
MX64 COL5 Net-_D62-Pad2_ MX-NoLED
D62 ROW3 Net-_D62-Pad2_ D_Small
MX65 COL6 Net-_D63-Pad2_ MX-NoLED
D63 ROW3 Net-_D63-Pad2_ D_Small
MX66 ALTCOL Net-_D64-Pad2_ MX-NoLED
D64 ROW3 Net-_D64-Pad2_ D_Small
MX67 COL8 Net-_D65-Pad2_ MX-NoLED
D65 ROW3 Net-_D65-Pad2_ D_Small
MX68 625SPCCOL Net-_D66-Pad2_ MX-NoLED
D66 ROW3 Net-_D66-Pad2_ D_Small
MX69 COL10 Net-_D67-Pad2_ MX-NoLED
D67 ROW3 Net-_D67-Pad2_ D_Small
MX70 COL11 Net-_D68-Pad2_ MX-NoLED
D68 ROW3 Net-_D68-Pad2_ D_Small
MX71 COL12 Net-_D69-Pad2_ MX-NoLED
D69 ROW3 Net-_D69-Pad2_ D_Small
MX72 COL13 Net-_D70-Pad2_ MX-NoLED
D70 ROW3 Net-_D70-Pad2_ D_Small
MX73 COL14 Net-_D71-Pad2_ MX-NoLED
D71 ROW3 Net-_D71-Pad2_ D_Small
MX74 COL15 Net-_D72-Pad2_ MX-NoLED
D72 ROW3 Net-_D72-Pad2_ D_Small
MX75 COL16 Net-_D73-Pad2_ MX-NoLED
D73 ROW3 Net-_D73-Pad2_ D_Small
MX79 COL0 Net-_D75-Pad2_ MX-NoLED
D75 ROW4 Net-_D75-Pad2_ D_Small
MX80 COL1 Net-_D76-Pad2_ MX-NoLED
D76 ROW4 Net-_D76-Pad2_ D_Small
MX81 COL2 Net-_D77-Pad2_ MX-NoLED
D77 ROW4 Net-_D77-Pad2_ D_Small
MX82 COL3 Net-_D78-Pad2_ MX-NoLED
D78 ROW4 Net-_D78-Pad2_ D_Small
MX83 COL4 Net-_D79-Pad2_ MX-NoLED
D79 ROW4 Net-_D79-Pad2_ D_Small
MX84 COL5 SHIFTROW MX-NoLED
D80 ROW4 SHIFTROW D_Small
MX85 COL6 Net-_D81-Pad2_ MX-NoLED
D81 ROW4 Net-_D81-Pad2_ D_Small
MX86 ALTCOL Net-_D82-Pad2_ MX-NoLED
D82 ROW4 Net-_D82-Pad2_ D_Small
MX87 COL8 Net-_D83-Pad2_ MX-NoLED
D83 ROW4 Net-_D83-Pad2_ D_Small
MX88 625SPCCOL Net-_D84-Pad2_ MX-NoLED
D84 ROW4 Net-_D84-Pad2_ D_Small
MX89 COL10 Net-_D85-Pad2_ MX-NoLED
D85 ROW4 Net-_D85-Pad2_ D_Small
MX90 COL11 Net-_D86-Pad2_ MX-NoLED
D86 ROW4 Net-_D86-Pad2_ D_Small
MX91 COL12 Net-_D87-Pad2_ MX-NoLED
D87 ROW4 Net-_D87-Pad2_ D_Small
MX92 COL13 Net-_D88-Pad2_ MX-NoLED
D88 ROW4 Net-_D88-Pad2_ D_Small
MX93 COL14 Net-_D89-Pad2_ MX-NoLED
D89 ROW4 Net-_D89-Pad2_ D_Small
MX94 COL15 Net-_D90-Pad2_ MX-NoLED
D90 ROW4 Net-_D90-Pad2_ D_Small
MX95 COL16 Net-_D91-Pad2_ MX-NoLED
D91 ROW4 Net-_D91-Pad2_ D_Small
MX96 COL17 UNSPLITROW MX-NoLED
D92 ROW4 UNSPLITROW D_Small
MX99 COL0 NP0ROW MX-NoLED
D94 ROW5 NP0ROW D_Small
MX100 COL1 Net-_D95-Pad2_ MX-NoLED
D95 ROW5 Net-_D95-Pad2_ D_Small
MX101 COL2 Net-_D96-Pad2_ MX-NoLED
D96 ROW5 Net-_D96-Pad2_ D_Small
MX102 COL3 Net-_D97-Pad2_ MX-NoLED
D97 ROW5 Net-_D97-Pad2_ D_Small
MX103 COL4 Net-_D98-Pad2_ MX-NoLED
D98 ROW5 Net-_D98-Pad2_ D_Small
MX104 COL5 Net-_D99-Pad2_ MX-NoLED
D99 ROW5 Net-_D99-Pad2_ D_Small
MX105 COL6 CONTROLROW MX-NoLED
D100 ROW5 CONTROLROW D_Small
MX106 ALTCOL ALTROW MX-NoLED
D101 ROW5 ALTROW D_Small
MX107 COL8 Net-_D102-Pad2_ MX-NoLED
D102 ROW5 Net-_D102-Pad2_ D_Small
MX108 625SPCCOL 625SPCROW MX-NoLED
D103 ROW5 625SPCROW D_Small
MX109 COL10 Net-_D104-Pad2_ MX-NoLED
D104 ROW5 Net-_D104-Pad2_ D_Small
MX110 COL11 Net-_D105-Pad2_ MX-NoLED
D105 ROW5 Net-_D105-Pad2_ D_Small
MX111 COL12 MOD1ROW MX-NoLED
D106 ROW5 MOD1ROW D_Small
MX112 COL13 MOD2ROW MX-NoLED
D107 ROW5 MOD2ROW D_Small
MX113 COL14 MOD3ROW MX-NoLED
D108 ROW5 MOD3ROW D_Small
MX120 COL0 NP0ROW MX-NoLED
MX38 COL3 NP+ROW MX-NoLED
MX78 COL5 SHIFTROW MX-NoLED
MX58 COL18 ISOENTERROW MX-NoLED
MX77 COL17 ISOKEYROW MX-NoLED
MX97 COL18 Net-_D93-Pad2_ MX-NoLED
D93 ROW4 Net-_D93-Pad2_ D_Small
MX98 COL17 UNSPLITROW MX-NoLED
MX114 COL6 CONTROLROW MX-NoLED
MX115 ALTCOL ALTROW MX-NoLED
MX116 625SPCCOL 625SPCROW MX-NoLED
MX117 COL12 MOD1ROW MX-NoLED
MX118 COL13 MOD2ROW MX-NoLED
MX119 COL14 MOD3ROW MX-NoLED
SW2 ENC1A ENC1B GND ENC1ROW COL4 Rotary_Encoder_Switch
SW3 ENC2A ENC2B GND ENC2ROW COL4 Rotary_Encoder_Switch
SW4 ENC3A ENC3B GND ENC3ROW COL4 Rotary_Encoder_Switch
C_VDD4 +3V3 GND 100n
R_USB1 +3V3 USB_D+ 1.5k
MX76 COL17 ISOKEYROW MX-NoLED
D74 ROW3 ISOKEYROW D_Small
D56 ROW2 ISOENTERROW D_Small
MX57 COL18 ISOENTERROW MX-NoLED
U3 +3V3 ALTCOL COL8 625SPCCOL XTAL_IN XTAL_OUT NRST ENC1A ENC2A ENC3A ENC1B GND +3V3 COL10 COL11 COL12 COL13 NC_08 +3V3 COL14 NC_09 NC_10 COL15 ENC2B ENC3B ROW0 ROW1 ROW2 NC_11 NC_12 GND +3V3 NC_13 NC_14 NC_15 NC_16 COL0 COL1 COL2 COL3 COL16 COL17 COL18 USB_D- USB_D+ SWDIO GND +3V3 SWCLK NC_17 COL4 COL5 COL6 NC_18 ROW3 ROW4 RGB LEDSTAT1 LEDSTAT2 BOOT0 LEDSTAT3 ROW5 GND +3V3 STM32F303RCTx
C_RESET1 GND NRST 100nF
R_RGB1 RGB +5V 10k
.end
