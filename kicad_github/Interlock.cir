.title KiCad schematic
C4 +3V3 GND 104
C5 +3V3 GND 104
C6 +3V3 GND 104
C7 +3V3 GND 104
C8 +3V3 GND 104
C3 +3V3 GND 104
C2 +3V3 GND 104
C1 +3V3 GND 104
SW2 GND GND NC_01 /SW2_1 /SW2_2 /SW2_3 /SW2_4 /SW2_5 /SW2_6 GND SRBV170501
SW4 /REMOTE GND REMOTE
SW3 /LOAD GND LOAD
J1 /TCK GND /TDO +3V3 /TMS NC_02 +3V3 NC_03 /TDI GND Blaster JTAG
SEG1 Net-_R5-Pad1_ Net-_R4-Pad1_ Net-_Q1-Pad3_ Net-_R3-Pad1_ Net-_R8-Pad1_ Net-_R2-Pad1_ Net-_R1-Pad1_ Net-_Q1-Pad3_ Net-_R6-Pad1_ Net-_R7-Pad1_ 0.56'' BLUE CA
R1 Net-_R1-Pad1_ /SEG1_A 33
R2 Net-_R2-Pad1_ /SEG1_B 33
R3 Net-_R3-Pad1_ /SEG1_C 33
R4 Net-_R4-Pad1_ /SEG1_D 33
R5 Net-_R5-Pad1_ /SEG1_E 33
R6 Net-_R6-Pad1_ /SEG1_F 33
R7 Net-_R7-Pad1_ /SEG1_G 33
R8 Net-_R8-Pad1_ /SEG1_DP 33
R9 Net-_R9-Pad1_ /SEG2_A 33
R11 Net-_R11-Pad1_ /SEG2_B 33
R12 Net-_R12-Pad1_ /SEG2_C 33
R13 Net-_R13-Pad1_ /SEG2_D 33
R14 Net-_R14-Pad1_ /SEG2_E 33
R15 Net-_R15-Pad1_ /SEG2_F 33
R16 Net-_R16-Pad1_ /SEG2_G 33
R17 Net-_R17-Pad1_ /SEG2_DP 33
Q1 Net-_Q1-Pad1_ +3V3 Net-_Q1-Pad3_ 8550
Q2 Net-_Q2-Pad1_ +3V3 Net-_Q2-Pad3_ 8550
R10 Net-_Q1-Pad1_ /SEG1 1K
J3 +12V +3V3 Net-_J3-Pad3_ Net-_J3-Pad4_ Net-_J3-Pad5_ Net-_J3-Pad6_ Net-_J3-Pad7_ Net-_J3-Pad8_ Conn_01x08
J4 Net-_J4-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ Net-_J4-Pad4_ Net-_J4-Pad5_ Net-_J4-Pad6_ GND GND Conn_01x08
D1 Net-_D1-Pad1_ +3V3 Remote
R25 Net-_D1-Pad1_ /REMOTE 4.7K
Q8 Net-_Q8-Pad1_ GND Net-_Q8-Pad3_ 8050
Q7 Net-_Q7-Pad1_ GND Net-_Q7-Pad3_ 8050
Q6 Net-_Q6-Pad1_ GND Net-_Q6-Pad3_ 8050
Q5 Net-_Q5-Pad1_ GND Net-_Q5-Pad3_ 8050
Q4 Net-_Q4-Pad1_ GND Net-_Q4-Pad3_ 8050
Q3 Net-_Q3-Pad1_ GND Net-_Q3-Pad3_ 8050
Q14 Net-_Q14-Pad1_ GND Net-_Q14-Pad3_ 8050
Q13 Net-_Q13-Pad1_ GND Net-_Q13-Pad3_ 8050
Q12 Net-_Q12-Pad1_ GND Net-_Q12-Pad3_ 8050
Q11 Net-_Q11-Pad1_ GND Net-_Q11-Pad3_ 8050
Q10 Net-_Q10-Pad1_ GND Net-_Q10-Pad3_ 8050
Q9 Net-_Q9-Pad1_ GND Net-_Q9-Pad3_ 8050
Q15 Net-_Q15-Pad1_ +12V Net-_J3-Pad3_ 8550
R26 Net-_Q3-Pad3_ Net-_Q15-Pad1_ 4.7K
Q16 Net-_Q16-Pad1_ +12V Net-_J3-Pad4_ 8550
Q17 Net-_Q17-Pad1_ +12V Net-_J3-Pad5_ 8550
Q18 Net-_Q18-Pad1_ +12V Net-_J3-Pad6_ 8550
Q19 Net-_Q19-Pad1_ +12V Net-_J3-Pad7_ 8550
Q20 Net-_Q20-Pad1_ +12V Net-_J3-Pad8_ 8550
Q21 Net-_Q21-Pad1_ +12V Net-_J4-Pad1_ 8550
Q22 Net-_Q22-Pad1_ +12V Net-_J4-Pad2_ 8550
Q23 Net-_Q23-Pad1_ +12V Net-_J4-Pad3_ 8550
Q24 Net-_Q24-Pad1_ +12V Net-_J4-Pad4_ 8550
Q25 Net-_Q25-Pad1_ +12V Net-_J4-Pad5_ 8550
Q26 Net-_Q26-Pad1_ +12V Net-_J4-Pad6_ 8550
R27 Net-_Q4-Pad3_ Net-_Q16-Pad1_ 4.7K
R28 Net-_Q5-Pad3_ Net-_Q17-Pad1_ 4.7K
R29 Net-_Q6-Pad3_ Net-_Q18-Pad1_ 4.7K
R30 Net-_Q7-Pad3_ Net-_Q19-Pad1_ 4.7K
R31 Net-_Q8-Pad3_ Net-_Q20-Pad1_ 4.7K
R32 Net-_Q9-Pad3_ Net-_Q21-Pad1_ 4.7K
R33 Net-_Q10-Pad3_ Net-_Q22-Pad1_ 4.7K
R34 Net-_Q11-Pad3_ Net-_Q23-Pad1_ 4.7K
R35 Net-_Q12-Pad3_ Net-_Q24-Pad1_ 4.7K
R36 Net-_Q13-Pad3_ Net-_Q25-Pad1_ 4.7K
R37 Net-_Q14-Pad3_ Net-_Q26-Pad1_ 4.7K
SEG2 Net-_R14-Pad1_ Net-_R13-Pad1_ Net-_Q2-Pad3_ Net-_R12-Pad1_ Net-_R17-Pad1_ Net-_R11-Pad1_ Net-_R9-Pad1_ Net-_Q2-Pad3_ Net-_R15-Pad1_ Net-_R16-Pad1_ 0.56'' BLUE CA
SW1 GND GND NC_04 /SW1_1 /SW1_2 /SW1_3 /SW1_4 /SW1_5 /SW1_6 GND SRBV170501
U1 NC_05 /SW1_3 /SW1_2 /SW1_1 /SW1_4 /SW1_5 /SW1_6 NC_06 +3V3 GND GND NC_07 +3V3 NC_08 /SW2_1 /SW2_2 /SW2_3 /SW2_4 /SW2_5 /SW2_6 NC_09 /TMS /TDI /TCK /TDO NC_10 /CPLDRST NC_11 NC_12 NC_13 +3V3 GND /LOAD /REMOTE /SEL2_6 /SEL1_6 /SEL2_5 /SEL1_5 /SEL2_4 /SEL1_4 /SEL2_3 /SEL1_3 /SEL2_2 /SEL1_2 +3V3 GND /SEL2_1 /SEL1_1 NC_14 /SEG1 /SEG1_D /SEG1_E /SEG1_C /SEG1_DP /SEG1_B /SEG1_A /SEG1_F /SEG1_G +3V3 GND NC_15 NC_16 +3V3 NC_17 GND /SEG2_E /SEG2_G /SEG2_D /SEG2_F /SEG2_C /SEG2_A /SEG2_DP /SEG2_B Net-_R18-Pad2_ NC_18 NC_19 NC_20 NC_21 GND +3V3 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 GND +3V3 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 EPM240T100
C43 /CPLDRST GND 104
R19 +3V3 /CPLDRST 1K
J9 /CPLDRST RST
U2 /SEL1_1 Net-_R21-Pad1_ /SEL2_1 Net-_R22-Pad1_ /SEL1_2 Net-_R23-Pad1_ GND Net-_R24-Pad1_ /SEL2_2 Net-_R38-Pad1_ /SEL1_3 Net-_R39-Pad1_ /SEL2_3 +3V3 74HC04
U9 /SEL1_4 Net-_R40-Pad1_ /SEL2_4 Net-_R41-Pad1_ /SEL1_5 Net-_R42-Pad1_ GND Net-_R43-Pad1_ /SEL2_5 Net-_R60-Pad1_ /SEL1_6 Net-_R61-Pad1_ /SEL2_6 +3V3 74HC04
R21 Net-_R21-Pad1_ Net-_Q3-Pad1_ 47K
R22 Net-_R22-Pad1_ Net-_Q4-Pad1_ 47K
R23 Net-_R23-Pad1_ Net-_Q5-Pad1_ 47K
R24 Net-_R24-Pad1_ Net-_Q6-Pad1_ 47K
R38 Net-_R38-Pad1_ Net-_Q7-Pad1_ 47K
R39 Net-_R39-Pad1_ Net-_Q8-Pad1_ 47K
R40 Net-_R40-Pad1_ Net-_Q9-Pad1_ 47K
R41 Net-_R41-Pad1_ Net-_Q10-Pad1_ 47K
R42 Net-_R42-Pad1_ Net-_Q11-Pad1_ 47K
R43 Net-_R43-Pad1_ Net-_Q12-Pad1_ 47K
R60 Net-_R60-Pad1_ Net-_Q13-Pad1_ 47K
R61 Net-_R61-Pad1_ Net-_Q14-Pad1_ 47K
R18 Net-_Q2-Pad1_ Net-_R18-Pad2_ 1K
.end
