.title KiCad schematic
U1 +3V3 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 -VDC +5V -VDC NC_19 /Leg/Current NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 /power/Ql /power/QH /Leg/QL /Leg/QH +3V3 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 -VDC +5V -VDC /Leg 2/Current NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 /Leg 2/QL /Leg 2/QH LAUNCHXL-F28379D
Q1 Net-_Q1-Pad1_ +VDC /power/OUT CSD19531KCS
Q2 Net-_Q2-Pad1_ /power/OUT -VDC CSD19531KCS
U2 /power/QH /power/Ql -VDC Net-_R2-Pad1_ +15V /power/OUT Net-_R1-Pad1_ Net-_C2-Pad1_ IR2181
R1 Net-_R1-Pad1_ Net-_Q1-Pad1_ 22R
R2 Net-_R2-Pad1_ Net-_Q2-Pad1_ 22R
C1 +15V -VDC 100n
C2 Net-_C2-Pad1_ /power/OUT 100n
D1 Net-_C2-Pad1_ +15V LL4148
J1 /Leg/Sensor/OUT Pusa_4mm
J2 /Leg/Power-/OUT Pusa_4mm
Q3 Net-_Q3-Pad1_ +VDC /Leg/Sensor/IN CSD19531KCS
Q4 Net-_Q4-Pad1_ /Leg/Sensor/IN -VDC CSD19531KCS
U3 /Leg/QH /Leg/QL -VDC Net-_R4-Pad1_ +15V /Leg/Sensor/IN Net-_R3-Pad1_ Net-_C4-Pad1_ IR2181
R3 Net-_R3-Pad1_ Net-_Q3-Pad1_ 22R
R4 Net-_R4-Pad1_ Net-_Q4-Pad1_ 22R
C3 +15V -VDC 100n
C4 Net-_C4-Pad1_ /Leg/Sensor/IN 100n
D2 Net-_C4-Pad1_ +15V LL4148
R5 /Leg/Sensor/OUT Net-_R5-Pad2_ Net-_R5-Pad3_ /Leg/Sensor/IN R_Shunt
U4 NC_65 Net-_R5-Pad3_ Net-_R5-Pad2_ -VDC +3V3 +3V3 -VDC /Leg/Current INA240
C5 +3V3 -VDC C1206
Q5 Net-_Q5-Pad1_ +VDC /Leg/Power-/OUT CSD19531KCS
Q6 Net-_Q6-Pad1_ /Leg/Power-/OUT -VDC CSD19531KCS
U5 /Leg/QL /Leg/QH -VDC Net-_R7-Pad1_ +15V /Leg/Power-/OUT Net-_R6-Pad1_ Net-_C7-Pad1_ IR2181
R6 Net-_R6-Pad1_ Net-_Q5-Pad1_ 22R
R7 Net-_R7-Pad1_ Net-_Q6-Pad1_ 22R
C6 +15V -VDC 100n
C7 Net-_C7-Pad1_ /Leg/Power-/OUT 100n
D3 Net-_C7-Pad1_ +15V LL4148
J3 /Leg 2/Sensor/OUT Pusa_4mm
J4 /Leg 2/Power-/OUT Pusa_4mm
Q7 Net-_Q7-Pad1_ +VDC /Leg 2/Sensor/IN CSD19531KCS
Q8 Net-_Q8-Pad1_ /Leg 2/Sensor/IN -VDC CSD19531KCS
U6 /Leg 2/QH /Leg 2/QL -VDC Net-_R9-Pad1_ +15V /Leg 2/Sensor/IN Net-_R8-Pad1_ Net-_C9-Pad1_ IR2181
R8 Net-_R8-Pad1_ Net-_Q7-Pad1_ 22R
R9 Net-_R9-Pad1_ Net-_Q8-Pad1_ 22R
C8 +15V -VDC 100n
C9 Net-_C9-Pad1_ /Leg 2/Sensor/IN 100n
D4 Net-_C9-Pad1_ +15V LL4148
R10 /Leg 2/Sensor/OUT Net-_R10-Pad2_ Net-_R10-Pad3_ /Leg 2/Sensor/IN R_Shunt
U7 NC_66 Net-_R10-Pad3_ Net-_R10-Pad2_ -VDC +3V3 +3V3 -VDC /Leg 2/Current INA240
C10 +3V3 -VDC C1206
Q9 Net-_Q9-Pad1_ +VDC /Leg 2/Power-/OUT CSD19531KCS
Q10 Net-_Q10-Pad1_ /Leg 2/Power-/OUT -VDC CSD19531KCS
U8 /Leg 2/QL /Leg 2/QH -VDC Net-_R12-Pad1_ +15V /Leg 2/Power-/OUT Net-_R11-Pad1_ Net-_C12-Pad1_ IR2181
R11 Net-_R11-Pad1_ Net-_Q9-Pad1_ 22R
R12 Net-_R12-Pad1_ Net-_Q10-Pad1_ 22R
C11 +15V -VDC 100n
C12 Net-_C12-Pad1_ /Leg 2/Power-/OUT 100n
D5 Net-_C12-Pad1_ +15V LL4148
.end
