.title KiCad schematic
U101 GND +3V3 /EN /I36 NC_01 NC_02 /BAT_MON /IO32 /IO33 /IO25 /I2C_SDA /I2C_SCL /IO14 /IO12 GND /IO13 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 /IO15 /IO2 /IO0 /EINK_MOSI /EINK_SCLK /EINK_CS /EINK_D/C /EINK_RST /EINK_BUSY NC_09 /IO21 /TXD /RXD /IO22 /IO23 GND GND ESP32-WROOM
R101 /IO0 Net-_C101-Pad1_ 470R
C101 Net-_C101-Pad1_ GND 1uF 6.3V
SW101 GND Net-_C101-Pad1_ PRGM
R102 /EN Net-_C102-Pad1_ 470R
C102 Net-_C102-Pad1_ GND 1uF 6.3V
SW102 GND Net-_C102-Pad1_ RESET
R106 /EN +3V3 12K
P101 /USB_VCC /USB_D- /USB_D+ NC_10 GND GND USB
U102 NC_11 NC_12 GND /USB_D+ /USB_D- +3V3 +3V3 /USB_VCC NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 /RTS /RXD Net-_R105-Pad2_ NC_28 /DTR GND CP2102
C107 /USB_VCC GND 0.1uF
C106 /USB_VCC GND 10uF
C105 +3V3 GND 0.1uF
C104 +3V3 GND 10uF
R105 /TXD Net-_R105-Pad2_ 470R
R108 Net-_Q102-Pad1_ /RTS 12K(1%)
R107 Net-_Q101-Pad1_ /DTR 12K(1%)
R103 /BAT_MON /BAT+ 1M 1%
R104 /BAT_MON GND 100K 1%
P102 GND Net-_F101-Pad1_ BATTERY
F101 Net-_F101-Pad1_ /BAT+ 1A PTC
D101 /BAT+ GND SS14
P106 /IO12 /IO14 POT_SHORT
P109 NC_29 MECH
P108 NC_30 MECH
P107 NC_31 MECH
Q101 Net-_Q101-Pad1_ /RTS /EN S8050
Q102 Net-_Q102-Pad1_ /DTR /IO0 S8050
P103 /IO2 /IO15 /IO13 POT_LONG
P104 /IO33 BUTTON_A
P105 /IO32 BUTTON_B
J101 +3V3 /I36 /IO23 /LED_DOUT /IO21 /IO0 /IO25 /I2C_SDA /I2C_SCL GND EDGE_CONNECTOR
C103 /EN GND 1uF
R203 Net-_R203-Pad1_ Net-_D203-Pad1_ 470R
D203 Net-_D203-Pad1_ Net-_C201-Pad1_ CHRG
C201 Net-_C201-Pad1_ GND 4.7uF
R202 Net-_R202-Pad1_ GND 2K 5%
SW201 /hipster-power/UNREG_V /LED_VIN ON|OFF
C203 +3V3 GND 1uF
C204 +3V3 GND 100uF 10V X5R
U201 Net-_R203-Pad1_ GND /BAT+ Net-_C201-Pad1_ Net-_R202-Pad1_ MCP73831
C202 /BAT+ GND 4.7uF
D201 /hipster-power/UNREG_V /USB_VCC SS14
R201 /USB_VCC GND 12K
D202 Net-_C201-Pad1_ /USB_VCC SS14
Q201 /USB_VCC /BAT+ /hipster-power/UNREG_V FDN340P
U202 /LED_VIN GND /LED_VIN NC_32 +3V3 XC6210A33MR-G
P301 NC_33 /E-Ink Display/GDR /E-Ink Display/RESE /E-Ink Display/VGL /E-Ink Display/VGH NC_34 NC_35 GND /EINK_BUSY /EINK_RST /EINK_D/C /EINK_CS /EINK_SCLK /EINK_MOSI +3V3 +3V3 GND /E-Ink Display/LCD_VDD NC_36 /E-Ink Display/VSH /E-Ink Display/PREVGH /E-Ink Display/VSL /E-Ink Display/PREVGL /E-Ink Display/VCOM eInk
C304 /E-Ink Display/VGL GND 1uF 25V
C305 /E-Ink Display/VGH GND 1uF 25V
C308 GND +3V3 1uF 25V
C309 GND +3V3 1uF 25V
C310 /E-Ink Display/VSH GND 1uF 25V
C311 /E-Ink Display/VSL GND 1uF 25V
C312 /E-Ink Display/VCOM GND 1uF 25V
R301 +3V3 /E-Ink Display/LCD_VDD 0R NP
C301 GND /E-Ink Display/LCD_VDD 1uF
C307 Net-_C307-Pad1_ GND 1uF 25V
L301 Net-_C307-Pad1_ Net-_C306-Pad1_ 47uH 410MA
D301 /E-Ink Display/PREVGH Net-_C306-Pad1_ SD103AWS
C302 /E-Ink Display/PREVGH GND 1uF 25V
D302 GND Net-_C306-Pad2_ SD103AWS
C303 /E-Ink Display/PREVGL GND 1uF 25V
D303 Net-_C306-Pad2_ /E-Ink Display/PREVGL SD103AWS
C306 Net-_C306-Pad1_ Net-_C306-Pad2_ 1uF 25V
R302 /E-Ink Display/RESE GND 2R7, 1%
Q301 /E-Ink Display/GDR /E-Ink Display/RESE Net-_C306-Pad1_ IRLML0030TRPBF
Q401 /IO22 GND /LED BlinkenLights/LED_GND Q_NMOS_GSD
R402 /IO22 GND 12K
LED401 /LED_VIN Net-_LED401-Pad2_ /LED BlinkenLights/LED_GND Net-_LED401-Pad4_ WS2812B
R401 Net-_LED401-Pad4_ /IO23 470R
C401 /LED_VIN /LED BlinkenLights/LED_GND 4.7uF
LED402 /LED_VIN Net-_LED402-Pad2_ /LED BlinkenLights/LED_GND Net-_LED401-Pad2_ WS2812B
LED403 /LED_VIN Net-_LED403-Pad2_ /LED BlinkenLights/LED_GND Net-_LED402-Pad2_ WS2812B
LED404 /LED_VIN /LED_DOUT /LED BlinkenLights/LED_GND Net-_LED403-Pad2_ WS2812B
.end
