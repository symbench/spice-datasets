.title KiCad schematic
J2 NC_01 NC_02 AudioJack2
J3 NC_03 NC_04 AudioJack2
J4 NC_05 NC_06 AudioJack2
P1 Net-_P1-PadA1_ Net-_P1-PadA4_ NC_07 NC_08 NC_09 Net-_P1-PadA4_ Net-_P1-PadA1_ Net-_P1-PadA1_ Net-_P1-PadA4_ NC_10 Net-_P1-PadA4_ Net-_P1-PadA1_ NC_11 USB_C_Plug_USB2.0
SW1 NC_12 NC_13 NC_14 NC_15 NC_16 SW_Coded
SW2 NC_17 NC_18 NC_19 NC_20 NC_21 SW_Coded
J1 NC_22 NC_23 NC_24 NC_25 NC_26 DIN-5_180degree
J8 NC_27 NC_28 AudioJack2
J9 NC_29 NC_30 AudioJack2
J10 NC_31 NC_32 AudioJack2
J5 NC_33 NC_34 AudioJack2
J6 NC_35 NC_36 AudioJack2
J7 NC_37 NC_38 AudioJack2
J11 NC_39 NC_40 AudioJack2
J12 NC_41 NC_42 AudioJack2
J13 NC_43 NC_44 AudioJack2
U1 +3V3 NC_45 NC_46 NC_47 Net-_C2-Pad1_ Net-_R2-Pad2_ /NRST NC_48 NC_49 NC_50 NC_51 GNDA VDDA NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 GND +3V3 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 /SWDIO NC_82 NC_83 /SWCLK NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 Net-_R1-Pad1_ NC_94 NC_95 GND +3V3 STM32F030R8Tx
Y1 Net-_C2-Pad1_ Net-_C3-Pad1_ 8 MHz
C2 Net-_C2-Pad1_ GND 20p?
C3 Net-_C3-Pad1_ GND 20p?
C1 /NRST GND 100n
SW3 GND GND /NRST /NRST SW_MEC_5E
J14 +3V3 /SWDIO GND /SWCLK GND NC_96 NC_97 NC_98 GND /NRST Conn_02x05_Odd_Even
R1 Net-_R1-Pad1_ GND R_Small
R2 Net-_C3-Pad1_ Net-_R2-Pad2_ 390?
C4 GNDA VDDA 1u
C5 GNDA VDDA 10n
C6 GND +3V3 100n
C7 GND +3V3 100n
C8 GND +3V3 4.7u
U2 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 NC_111 NC_112 NC_113 NC_114 NC_115 NC_116 NC_117 NC_118 NC_119 NC_120 NC_121 NC_122 NC_123 NC_124 NC_125 NC_126 NC_127 NC_128 NC_129 NC_130 NC_131 NC_132 NC_133 NC_134 NC_135 NC_136 NC_137 NC_138 NC_139 NC_140 NC_141 NC_142 NC_143 NC_144 NC_145 NC_146 STM32F070CBTx
.end
