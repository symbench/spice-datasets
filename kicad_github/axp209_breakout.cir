.title KiCad schematic
U1 SDA SCL GP3 Net-_J6-Pad2_ GP2 Net-_J7-Pad2_ IPSOUT Net-_L2-Pad2_ GND DCDC2 LDO4 LDO1 Net-_C10-Pad2_ IPSOUT Net-_L3-Pad2_ GND DCDC3 GP1 GP0 EXTEN Net-_C7-Pad2_ GND Net-_R5-Pad2_ Net-_C8-Pad2_ RSTO Net-_C9-Pad2_ Net-_J9-Pad2_ LDO0 Net-_J10-Pad2_ VRTC VBUS ACIN ACIN IPSOUT IPSOUT Net-_R3-Pad2_ Net-_R6-Pad2_ +BATT +BATT IPSOUT NC_01 +BATT Net-_C15-Pad2_ IPSOUT Net-_L1-Pad2_ GND Net-_C6-Pad2_ IRQ GND axp209
J3 GND IRQ SCL SDA VCCIO I2C
R12 +BATT Net-_C15-Pad2_ Shunt
J8 +BATT GND Net-_J8-Pad3_ BAT
R6 Net-_J8-Pad3_ Net-_R6-Pad2_ 0R
R8 GND Net-_J8-Pad3_ xR
R7 Net-_J8-Pad3_ +BATT xR
L1 Net-_C15-Pad2_ Net-_L1-Pad2_ L
C15 +BATT Net-_C15-Pad2_ xC
C21 GND +BATT xC
C22 GND Net-_C15-Pad2_ xC
L2 DCDC2 Net-_L2-Pad2_ L
L3 DCDC3 Net-_L3-Pad2_ L
D4 Net-_D4-Pad1_ IPSOUT LED
R3 Net-_D4-Pad1_ Net-_R3-Pad2_ 10K
R9 IPSOUT Net-_C10-Pad2_ 0R
C10 GND Net-_C10-Pad2_ xC
J9 GND Net-_J9-Pad2_ IPSOUT L1S
J10 IPSOUT Net-_J10-Pad2_ GND D3S
C16 GND LDO0 xC
C17 GND LDO1 xC
C19 GND IPSOUT xC
C20 GND LDO4 xC
C23 GND IPSOUT xC
C12 DCDC3 GND xC
C14 DCDC3 GND xC
C11 DCDC2 GND xC
C13 DCDC2 GND xC
R5 GND Net-_R5-Pad2_ xR
C9 GND Net-_C9-Pad2_ xxC
J5 GND VBUS Conn_01x02
C4 VBUS GND xC
C8 GND Net-_C8-Pad2_ xxC
C7 GND Net-_C7-Pad2_ xxC
R2 Net-_C7-Pad2_ IPSOUT 0R
C6 GND Net-_C6-Pad2_ xxC
J4 GND ACIN Conn_01x02
C3 ACIN GND xC
SW1 GND Net-_R1-Pad1_ PWR
R1 Net-_R1-Pad1_ Net-_C6-Pad2_ xR
J6 IPSOUT Net-_J6-Pad2_ GND OE
C5 +BATT GND xC
D3 +BATT GND D_Schottky
D1 ACIN GND D_Schottky
D2 VBUS GND D_Schottky
J11 VCCIO RSTO GND RST_O
J7 GND Net-_J7-Pad2_ IPSOUT VBUSEN
C1 IPSOUT GND xC
C2 IPSOUT GND xxC
J12 DCDC3 GND DC3
J1 GND GP2 GP3 GP23
J2 DCDC2 GND DC2
J13 LDO0 GND LD0
J14 LDO4 LDO1 GND LD14
TP2 GP1 GP1
SW2 GND Net-_R1-Pad1_ PWR
R14 SDA VCCIO 10K
R15 SCL VCCIO 10K
R16 IRQ VCCIO 10K
D5 Net-_D5-Pad1_ VCCIO LED
R17 Net-_D5-Pad1_ GND 10K
D6 Net-_D6-Pad1_ ACIN LED
R18 Net-_D6-Pad1_ GND 10K
D7 Net-_D7-Pad1_ VBUS LED
R19 Net-_D7-Pad1_ GND 10K
D8 Net-_D8-Pad1_ +BATT LED
R20 Net-_D8-Pad1_ GND 10K
D10 Net-_D10-Pad1_ DCDC2 LED
R22 Net-_D10-Pad1_ GND 10K
D9 Net-_D9-Pad1_ DCDC3 LED
R21 Net-_D9-Pad1_ GND 10K
D11 Net-_D11-Pad1_ LDO0 LED
R23 Net-_D11-Pad1_ GND 10K
Q1 Net-_Q1-Pad1_ GND Net-_Q1-Pad3_ BC817
R10 EXTEN Net-_Q1-Pad1_ xR
R4 EXTEN GND xR
Q2 Net-_Q1-Pad3_ IPSOUT IPS_PSU Q_PMOS_GSD
R11 IPSOUT Net-_Q1-Pad3_ xR
C18 GND IPS_PSU xC
J15 IPS_PSU GND IPS_PSU
TP1 GP0 GP0
TP3 VRTC VRTC
.end
