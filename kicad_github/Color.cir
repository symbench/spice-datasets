.title KiCad schematic
U22 NC_01 NC_02 ~WR ~RD D0 D1 D2 D3 D4 D5 Net-_U22-Pad14_ D6 D7 Net-_U22-Pad17_ Net-_U22-Pad14_ /Palette Table/A4 /Palette Table/A5 /Palette Table/A6 Net-_U22-Pad17_ /Palette Table/A7 /Palette Table/A8 /Palette Table/A9 /Palette Table/A10 /Palette Table/A11 Net-_U22-Pad29_ NC_03 NC_04 Net-_U22-Pad29_ Net-_U22-Pad14_ /Color Table/A12 /Color Table/A11 /Color Table/A10 /Color Table/A9 /Color Table/A8 /Color Table/A7 /Color Table/A6 /Color Table/A5 /Color Table/A4 /Color Table/A3 /Color Table/A2 /Color Table/A1 /Color Table/A0 NC_05 NC_06 NC_07 Net-_U22-Pad14_ NC_08 NC_09 AC0 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AC10 AC11 AC12 Net-_U22-Pad17_ IDT7005J
U24 NC_10 NC_11 ~WR ~RD D0 D1 D2 D3 D4 D5 Net-_U24-Pad14_ D6 D7 Net-_U24-Pad17_ Net-_U24-Pad14_ NC_12 NC_13 NC_14 Net-_U24-Pad17_ NC_15 NC_16 NC_17 NC_18 NC_19 Net-_U24-Pad29_ NC_20 NC_21 Net-_U24-Pad29_ Net-_U24-Pad14_ NC_22 /Palette Table/A11 /Palette Table/A10 /Palette Table/A9 /Palette Table/A8 /Palette Table/A7 /Palette Table/A6 /Palette Table/A5 /Palette Table/A4 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 Net-_U24-Pad14_ NC_30 NC_31 AC0 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AC10 AC11 AC12 Net-_U24-Pad17_ IDT7005J
U21 NC_32 NC_33 ~WR ~RD D0 D1 D2 D3 D4 D5 Net-_U21-Pad14_ D6 D7 Net-_U21-Pad17_ Net-_U21-Pad14_ /Pattern Table/A5 /Pattern Table/A6 /Pattern Table/A7 Net-_U21-Pad17_ /Pattern Table/A8 /Pattern Table/A9 /Pattern Table/A10 /Pattern Table/A11 /Pattern Table/A12 Net-_U21-Pad29_ NC_34 NC_35 Net-_U21-Pad29_ Net-_U21-Pad14_ /Color Table/A12 /Color Table/A11 /Color Table/A10 /Color Table/A9 /Color Table/A8 /Color Table/A7 /Color Table/A6 /Color Table/A5 /Color Table/A4 /Color Table/A3 /Color Table/A2 /Color Table/A1 /Color Table/A0 NC_36 NC_37 NC_38 Net-_U21-Pad14_ NC_39 NC_40 AC0 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AC10 AC11 AC12 Net-_U21-Pad17_ IDT7005J
U23 NC_41 NC_42 ~WR ~RD D0 D1 D2 D3 D4 D5 Net-_U23-Pad14_ D6 D7 Net-_U23-Pad17_ Net-_U23-Pad14_ NC_43 NC_44 NC_45 Net-_U23-Pad17_ NC_46 NC_47 NC_48 NC_49 NC_50 Net-_U23-Pad29_ NC_51 NC_52 Net-_U23-Pad29_ Net-_U23-Pad14_ /Pattern Table/A12 /Pattern Table/A11 /Pattern Table/A10 /Pattern Table/A9 /Pattern Table/A8 /Pattern Table/A7 /Pattern Table/A6 /Pattern Table/A5 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 Net-_U23-Pad14_ NC_61 NC_62 AC0 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AC10 AC11 AC12 Net-_U23-Pad17_ IDT7005J
.end
