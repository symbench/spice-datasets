.title KiCad schematic
U1 COL5 COL6 COL7 NC_01 NC_02 MOSI MISO SCK reset +5V GND Net-_C2-Pad2_ Net-_C1-Pad2_ NC_03 NC_04 D+ D- boot COL8 COL9 EN1 EN2 COL14 COL13 COL12 COL11 COL10 ROW1 ROW2 +5V GND NC_05 ROW3 ROW0 ROW4 COL4 COL3 COL2 COL1 COL0 ATmega32A-PU
SW2 GND reset SW_Push
R6 +5V reset 10K
Y1 Net-_C1-Pad2_ Net-_C2-Pad2_ 16Mhz
C2 GND Net-_C2-Pad2_ 22pF
C1 GND Net-_C1-Pad2_ 22pF
U2 GND VCC Net-_R2-Pad2_ Net-_D70-Pad1_ Net-_D69-Pad1_ NC_06 VCC GND GND VCC Net-_R5-Pad2_ Net-_D70-Pad1_ Net-_D69-Pad1_ NC_07 VCC GND GND GCT-USB-4085-GF-A
R5 GND Net-_R5-Pad2_ 5.1K
R2 GND Net-_R2-Pad2_ 5.1K
R1 +5V Net-_D69-Pad1_ 1.5K
F1 +5V VCC 500mA
D70 Net-_D70-Pad1_ GND 3.6V
D69 Net-_D69-Pad1_ GND 3.6V
R4 D+ Net-_D70-Pad1_ 75
R3 D- Net-_D69-Pad1_ 75
J1 MISO +5V SCK MOSI reset GND AVR-ISP-6
SW1 GND boot SW_Push
C3 +5V GND 0.1uF
C4 +5V GND 0.1uF
C5 +5V GND 4.7uF
MX1 COL0 Net-_D1-Pad2_ MX-NoLED
D1 ROW0 Net-_D1-Pad2_ D_Small
MX2 COL1 Net-_D2-Pad2_ MX-NoLED
D2 ROW0 Net-_D2-Pad2_ D_Small
MX3 COL2 Net-_D3-Pad2_ MX-NoLED
D3 ROW0 Net-_D3-Pad2_ D_Small
MX4 COL3 Net-_D4-Pad2_ MX-NoLED
D4 ROW0 Net-_D4-Pad2_ D_Small
MX5 COL4 Net-_D5-Pad2_ MX-NoLED
D5 ROW0 Net-_D5-Pad2_ D_Small
MX6 COL5 Net-_D6-Pad2_ MX-NoLED
D6 ROW0 Net-_D6-Pad2_ D_Small
MX7 COL6 Net-_D7-Pad2_ MX-NoLED
D7 ROW0 Net-_D7-Pad2_ D_Small
MX8 COL7 Net-_D8-Pad2_ MX-NoLED
D8 ROW0 Net-_D8-Pad2_ D_Small
MX9 COL8 Net-_D9-Pad2_ MX-NoLED
D9 ROW0 Net-_D9-Pad2_ D_Small
MX10 COL9 Net-_D10-Pad2_ MX-NoLED
D10 ROW0 Net-_D10-Pad2_ D_Small
MX11 COL10 Net-_D11-Pad2_ MX-NoLED
D11 ROW0 Net-_D11-Pad2_ D_Small
MX12 COL11 Net-_D12-Pad2_ MX-NoLED
D12 ROW0 Net-_D12-Pad2_ D_Small
MX13 COL12 Net-_D13-Pad2_ MX-NoLED
D13 ROW0 Net-_D13-Pad2_ D_Small
MX14 COL13 Net-_D14-Pad2_ MX-NoLED
D14 ROW0 Net-_D14-Pad2_ D_Small
MX15 COL14 Net-_D15-Pad2_ MX-NoLED
D15 ROW0 Net-_D15-Pad2_ D_Small
MX16 COL0 Net-_D16-Pad2_ MX-NoLED
D16 ROW1 Net-_D16-Pad2_ D_Small
MX18 COL2 Net-_D18-Pad2_ MX-NoLED
D18 ROW1 Net-_D18-Pad2_ D_Small
MX19 COL3 Net-_D19-Pad2_ MX-NoLED
D19 ROW1 Net-_D19-Pad2_ D_Small
MX20 COL4 Net-_D20-Pad2_ MX-NoLED
D20 ROW1 Net-_D20-Pad2_ D_Small
MX21 COL5 Net-_D21-Pad2_ MX-NoLED
D21 ROW1 Net-_D21-Pad2_ D_Small
MX22 COL6 Net-_D22-Pad2_ MX-NoLED
D22 ROW1 Net-_D22-Pad2_ D_Small
MX23 COL7 Net-_D23-Pad2_ MX-NoLED
D23 ROW1 Net-_D23-Pad2_ D_Small
MX24 COL8 Net-_D24-Pad2_ MX-NoLED
D24 ROW1 Net-_D24-Pad2_ D_Small
MX25 COL9 Net-_D25-Pad2_ MX-NoLED
D25 ROW1 Net-_D25-Pad2_ D_Small
MX26 COL10 Net-_D26-Pad2_ MX-NoLED
D26 ROW1 Net-_D26-Pad2_ D_Small
MX27 COL11 Net-_D27-Pad2_ MX-NoLED
D27 ROW1 Net-_D27-Pad2_ D_Small
MX28 COL12 Net-_D28-Pad2_ MX-NoLED
D28 ROW1 Net-_D28-Pad2_ D_Small
MX29 COL13 Net-_D29-Pad2_ MX-NoLED
D29 ROW1 Net-_D29-Pad2_ D_Small
MX30 COL14 Net-_D30-Pad2_ MX-NoLED
D30 ROW1 Net-_D30-Pad2_ D_Small
MX31 COL0 Net-_D31-Pad2_ MX-NoLED
D31 ROW2 Net-_D31-Pad2_ D_Small
MX44 COL12 Net-_D43-Pad2_ MX-NoLED
D43 ROW2 Net-_D43-Pad2_ D_Small
D32 ROW2 Net-_D32-Pad2_ D_Small
MX34 COL2 Net-_D33-Pad2_ MX-NoLED
D33 ROW2 Net-_D33-Pad2_ D_Small
MX35 COL3 Net-_D34-Pad2_ MX-NoLED
D34 ROW2 Net-_D34-Pad2_ D_Small
MX36 COL4 Net-_D35-Pad2_ MX-NoLED
D35 ROW2 Net-_D35-Pad2_ D_Small
MX37 COL5 Net-_D36-Pad2_ MX-NoLED
D36 ROW2 Net-_D36-Pad2_ D_Small
MX38 COL6 Net-_D37-Pad2_ MX-NoLED
D37 ROW2 Net-_D37-Pad2_ D_Small
MX39 COL7 Net-_D38-Pad2_ MX-NoLED
D38 ROW2 Net-_D38-Pad2_ D_Small
MX40 COL8 Net-_D39-Pad2_ MX-NoLED
D39 ROW2 Net-_D39-Pad2_ D_Small
MX41 COL9 Net-_D40-Pad2_ MX-NoLED
D40 ROW2 Net-_D40-Pad2_ D_Small
MX42 COL10 Net-_D41-Pad2_ MX-NoLED
D41 ROW2 Net-_D41-Pad2_ D_Small
MX43 COL11 Net-_D42-Pad2_ MX-NoLED
D42 ROW2 Net-_D42-Pad2_ D_Small
MX45 COL13 Net-_D44-Pad2_ MX-NoLED
D44 ROW2 Net-_D44-Pad2_ D_Small
MX46 COL1 Net-_D45-Pad2_ MX-NoLED
D45 ROW3 Net-_D45-Pad2_ D_Small
MX47 COL2 Net-_D46-Pad2_ MX-NoLED
D46 ROW3 Net-_D46-Pad2_ D_Small
MX48 COL3 Net-_D47-Pad2_ MX-NoLED
D47 ROW3 Net-_D47-Pad2_ D_Small
MX49 COL4 Net-_D48-Pad2_ MX-NoLED
D48 ROW3 Net-_D48-Pad2_ D_Small
MX50 COL5 Net-_D49-Pad2_ MX-NoLED
D49 ROW3 Net-_D49-Pad2_ D_Small
MX51 COL6 Net-_D50-Pad2_ MX-NoLED
D50 ROW3 Net-_D50-Pad2_ D_Small
MX52 COL7 Net-_D51-Pad2_ MX-NoLED
D51 ROW3 Net-_D51-Pad2_ D_Small
MX53 COL8 Net-_D52-Pad2_ MX-NoLED
D52 ROW3 Net-_D52-Pad2_ D_Small
MX54 COL9 Net-_D53-Pad2_ MX-NoLED
D53 ROW3 Net-_D53-Pad2_ D_Small
MX55 COL10 Net-_D54-Pad2_ MX-NoLED
D54 ROW3 Net-_D54-Pad2_ D_Small
MX56 COL11 Net-_D55-Pad2_ MX-NoLED
D55 ROW3 Net-_D55-Pad2_ D_Small
MX58 COL13 Net-_D57-Pad2_ MX-NoLED
D57 ROW3 Net-_D57-Pad2_ D_Small
MX59 COL14 Net-_D58-Pad2_ MX-NoLED
D58 ROW2 Net-_D58-Pad2_ D_Small
D56 ROW3 Net-_D56-Pad2_ D_Small
MX57 COL12 Net-_D56-Pad2_ MX-NoLED
D60 ROW4 Net-_D60-Pad2_ D_Small
MX62 COL4 Net-_D61-Pad2_ MX-NoLED
D61 ROW4 Net-_D61-Pad2_ D_Small
MX63 COL6 Net-_D62-Pad2_ MX-NoLED
D62 ROW4 Net-_D62-Pad2_ D_Small
MX64 COL8 Net-_D63-Pad2_ MX-NoLED
D63 ROW4 Net-_D63-Pad2_ D_Small
D64 ROW4 Net-_D64-Pad2_ D_Small
MX67 COL12 Net-_D66-Pad2_ MX-NoLED
D66 ROW4 Net-_D66-Pad2_ D_Small
D67 ROW4 Net-_D67-Pad2_ D_Small
D68 ROW3 Net-_D68-Pad2_ D_Small
MX61 COL2 Net-_D60-Pad2_ MX-NoLED
MX65 COL10 Net-_D64-Pad2_ MX-NoLED
D59 ROW4 Net-_D59-Pad2_ D_Small
MX60 COL1 Net-_D59-Pad2_ MX-NoLED
MX17 COL1 Net-_D17-Pad2_ MX-NoLED
D17 ROW1 Net-_D17-Pad2_ D_Small
MX32 COL1 Net-_D32-Pad2_ MX-NoLED
MX66 COL11 Net-_D65-Pad2_ MX-NoLED
D65 ROW4 Net-_D65-Pad2_ D_Small
D71 Net-_D71-Pad1_ +5V LED
R7 Net-_D71-Pad1_ GND 1.5K
MX33 COL1 Net-_D32-Pad2_ MX-NoLED
SW3 EN1 EN2 GND COL14 Net-_D72-Pad2_ Rotary_Encoder_Switch
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
H5 MountingHole
H6 MountingHole
H7 MountingHole
H8 MountingHole
H9 MountingHole
H11 MountingHole
D72 ROW4 Net-_D72-Pad2_ D_Small
H13 MountingHole
MX68 COL13 Net-_D67-Pad2_ MX-NoLED
MX69 COL14 Net-_D68-Pad2_ MX-NoLED
MX71 COL6 Net-_D62-Pad2_ MX-NoLED
MX70 COL4 Net-_D61-Pad2_ MX-NoLED
.
.end
