.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_U1-Pad2_ NC_01 NC_02 NC_03 NC_04 Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ VCC Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ VCC VCC NC_05 Net-_U1-Pad19_ NC_06 Net-_U1-Pad21_ NC_07 NC_08 VCC VCC Net-_R1-Pad2_ NC_09 NC_10 GND Net-_U1-Pad30_ Net-_U1-Pad31_ Net-_U1-Pad32_ Net-_U1-Pad33_ Net-_U1-Pad34_ Net-_U1-Pad35_ Net-_U1-Pad36_ Net-_U1-Pad37_ Net-_U1-Pad38_ Net-_U1-Pad39_ Net-_U1-Pad40_ Z80ACPU
C1 VCC GND 1μF
R1 VCC Net-_R1-Pad2_ 470
SW1 GND Net-_R1-Pad2_ SW_SPST
U2 NC_11 Net-_U1-Pad2_ Net-_U1-Pad37_ Net-_U1-Pad36_ Net-_U1-Pad35_ Net-_U1-Pad34_ Net-_U1-Pad33_ Net-_U1-Pad32_ Net-_U1-Pad31_ Net-_U1-Pad30_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad12_ GND Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad13_ Net-_U1-Pad19_ Net-_U1-Pad40_ Net-_U1-Pad21_ Net-_U1-Pad1_ Net-_U1-Pad39_ Net-_U1-Pad38_ NC_12 VCC VCC AT28C64
U3 Net-_U1-Pad21_ Net-_U1-Pad14_ Net-_R6-Pad2_ Net-_U1-Pad15_ Net-_R7-Pad2_ Net-_U1-Pad12_ Net-_R8-Pad2_ Net-_U1-Pad8_ Net-_R9-Pad2_ GND Net-_U1-Pad13_ Net-_R5-Pad2_ Net-_U1-Pad10_ Net-_R4-Pad2_ Net-_U1-Pad9_ Net-_R3-Pad2_ Net-_U1-Pad7_ Net-_R2-Pad2_ Net-_U1-Pad21_ VCC 74HCT244
R2 Net-_D1-Pad2_ Net-_R2-Pad2_ 330
R3 Net-_D2-Pad2_ Net-_R3-Pad2_ 330
R4 Net-_D3-Pad2_ Net-_R4-Pad2_ 330
R5 Net-_D4-Pad2_ Net-_R5-Pad2_ 330
R6 Net-_D5-Pad2_ Net-_R6-Pad2_ 330
R7 Net-_D6-Pad2_ Net-_R7-Pad2_ 330
R8 Net-_D7-Pad2_ Net-_R8-Pad2_ 330
R9 Net-_D8-Pad2_ Net-_R9-Pad2_ 330
D1 GND Net-_D1-Pad2_ LED
D2 GND Net-_D2-Pad2_ LED
D3 GND Net-_D3-Pad2_ LED
D4 GND Net-_D4-Pad2_ LED
D5 GND Net-_D5-Pad2_ LED
D6 GND Net-_D6-Pad2_ LED
D7 GND Net-_D7-Pad2_ LED
D8 GND Net-_D8-Pad2_ LED
.end
