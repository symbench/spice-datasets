.title KiCad schematic
U3 Net-_R3-Pad1_ Net-_R5-Pad1_ Net-_R6-Pad2_ VP VPWM Net-_C4-Pad1_ HIFTRACK VSO NC_01 VTO Net-_C6-Pad2_ GND Net-_R1-Pad1_ Net-_R8-Pad2_ CVINPUTS +12V AS3340
C12 GND +12V 100nF
R3 Net-_R3-Pad1_ Net-_R3-Pad2_ 24K
R5 Net-_R5-Pad1_ Net-_R5-Pad2_ 5K6
C4 Net-_C4-Pad1_ SYNCIN1 1nF
R4 Net-_R1-Pad1_ +12V 1M5
R2 Net-_R1-Pad1_ GND 470R
R1 Net-_R1-Pad1_ Net-_C1-Pad2_ 1M
C1 FMINPUT Net-_C1-Pad2_ 100nF
C7 GND Net-_C7-Pad2_ 10nF
R7 Net-_C7-Pad2_ CVINPUTS 470R
C6 GND Net-_C6-Pad2_ 1nF
R8 GND Net-_R8-Pad2_ 1K8
R6 -12V Net-_R6-Pad2_ 680R
C5 -12V GND 100nF
U1 Net-_R19-Pad2_ Net-_R19-Pad2_ Net-_J13-Pad6_ +12V 1V Net-_RV7-Pad1_ Net-_RV7-Pad1_ RAMPOUT RAMPOUT VSO -12V VTO TRIANGLEOUT TRIANGLEOUT TL074
RV1 Net-_R3-Pad2_ Net-_R5-Pad2_ Net-_R6-Pad2_ 10K Track
U2 SQUAREOUT SQUAREOUT VP -12V Net-_R11-Pad2_ Net-_R14-Pad2_ VPWM +12V TL072
R9 VP GND 47K
J13 GND 1V Net-_J13-Pad3_ Net-_J13-Pad4_ REF Net-_J13-Pad6_ Octave
R16 1V GND 10K
R17 Net-_J13-Pad3_ 1V 10K
R18 Net-_J13-Pad4_ Net-_J13-Pad3_ 10K
R21 REF Net-_J13-Pad4_ 10K
R19 CVINPUTS Net-_R19-Pad2_ 100K
RV7 Net-_RV7-Pad1_ Net-_R24-Pad2_ GND 10OK
R24 CVINPUTS Net-_R24-Pad2_ 100K
RV6 GND Net-_R23-Pad2_ +12V 10OK
R23 CVINPUTS Net-_R23-Pad2_ 100K
C2 GND +12V 100nF
C3 GND -12V 100nF
C10 GND +12V 100nF
C11 GND -12V 100nF
R42 Net-_R42-Pad1_ +12V 220R
U4 Net-_R42-Pad1_ GND LM4040
RV3 GND REF Net-_R42-Pad1_ 100K REF TRIM
TP1 REF Voltage Test Point  4V
RV4 Net-_R13-Pad1_ Net-_R12-Pad2_ Net-_R10-Pad1_ 10OK
R10 Net-_R10-Pad1_ GND 1K
R12 Net-_R11-Pad2_ Net-_R12-Pad2_ 470K
R11 Net-_R11-Pad1_ Net-_R11-Pad2_ 470K
RV2 PWMIN Net-_R11-Pad1_ GND 10OK
R14 VPWM Net-_R14-Pad2_ 100K
R15 VPWM GND 4K7
R13 Net-_R13-Pad1_ +12V 470K
R22 CVINPUTS 1VOCTIN 100K
RV5 CVIN Net-_R20-Pad2_ GND 10OK CVLVL
R20 CVINPUTS Net-_R20-Pad2_ 470K
RV8 HIFTRACK Net-_R26-Pad2_ GND 20K HFTRACK
R26 CVINPUTS Net-_R26-Pad2_ 1M
J8 GND PWMIN NC_02 PWM
J2 GND SQUAREOUT NC_03 SQR
J9 GND FMINPUT NC_04 FM
J3 GND TRIANGLEOUT NC_05 TRI
J7 GND SYNCIN1 NC_06 SNC
J4 GND RAMPOUT NC_07 RMP
J6 GND CVIN NC_08 CV
J5 GND 1VOCTIN NC_09 1VO
J1 +12V +12V GND GND GND GND GND GND -12V -12V Filtered Power
C8 +12V GND 10uF
C9 GND -12V 10uF
.end
