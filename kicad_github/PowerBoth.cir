.title KiCad schematic
J202 GND GND Net-_J202-PadP$3_ /Charger/VBATT /Charger/VBATT 2MM-1X5
U201 Net-_CC201-Pad1_ Net-_C201-Pad1_ Net-_M201-Pad4_ GND Net-_R201-Pad1_ /Charger/VBATT Net-_L201-Pad1_ Net-_J202-PadP$3_ LTC4002ES8-4.2PBFSO-8_S-M
M201 Net-_C201-Pad1_ Net-_C201-Pad1_ Net-_C201-Pad1_ Net-_M201-Pad4_ Net-_D202-Pad1_ Net-_D202-Pad1_ Net-_D202-Pad1_ Net-_D202-Pad1_ IRF7205
L201 Net-_L201-Pad1_ Net-_D202-Pad1_ 6.8uH
D201 Net-_C201-Pad1_ /Charger/V+CH B330A-13
D202 Net-_D202-Pad1_ GND B330A-13
RSENSE201 /Charger/VBATT Net-_L201-Pad1_ 68mOhms
C202 Net-_C201-Pad1_ GND 10uF
C203 /Charger/VBATT GND 22uF
C201 Net-_C201-Pad1_ GND 0.1uF
CC201 Net-_CC201-Pad1_ Net-_CC201-Pad2_ 0.47uF
RC201 GND Net-_CC201-Pad2_ R-US_R1206
R201 Net-_R201-Pad1_ /Charger/CHSTAT 2K
R202 GND /Charger/V+CH 56K
Q201 /Charger/V+ToBoost /Charger/V+ToBoost /Charger/V+ToBoost /Charger/V+CH /Charger/VBATT /Charger/VBATT /Charger/VBATT /Charger/VBATT IRF7205
J201 /Charger/V+CH GND /Charger/CHG_CON Net-_J201-PadS1_ Net-_J201-PadS1_ PJ-079AH
D203 /Charger/V+ToBoost /Charger/V+CH B330A-13
TP201 /Charger/CHSTAT TEST_POINTROUND-1MM
TP202 /Charger/VBATT TEST_POINTROUND-1MM
U301 /SEPIC Converter/ISEN /SEPIC Converter/COMP /SEPIC Converter/FB GND GND /SEPIC Converter/DR /SEPIC Converter/FA /SEPIC Converter/VIN LM3488
L301 /Charger/V+ToBoost /SEPIC Converter/VOUT /SEPIC Converter/VIN3 GND INDUCTOR_DUAL
COUT303 5V GND 47uF
COUT301 5V GND 47uF
COUT302 5V GND 47uF
CCOMP301 /SEPIC Converter/COMP GND 15nF
RFB301 /SEPIC Converter/FB 5V 29.4K
CFILT301 /SEPIC Converter/ISEN GND 1.5nF
RSENSE301 GND /SEPIC Converter/SOURCE 0.009
CCOMP302 Net-_CCOMP302-Pad1_ GND 0.47uF
CSEP301 /SEPIC Converter/VOUT /SEPIC Converter/VIN3 3.3uF
CSEP302 /SEPIC Converter/VOUT /SEPIC Converter/VIN3 3.3uF
RFB302 GND /SEPIC Converter/FB 10k
CBP301 /SEPIC Converter/VIN GND 0.1uF
RFILT301 /SEPIC Converter/SOURCE /SEPIC Converter/ISEN 100
RFADJ301 GND /SEPIC Converter/FA 76.8K
RBP301 /SEPIC Converter/VIN /Charger/V+ToBoost 20
RCOMP301 Net-_CCOMP302-Pad1_ /SEPIC Converter/COMP 215
M301 /SEPIC Converter/SOURCE /SEPIC Converter/SOURCE /SEPIC Converter/SOURCE /SEPIC Converter/DR /SEPIC Converter/VIN3 /SEPIC Converter/VIN3 /SEPIC Converter/VIN3 /SEPIC Converter/VIN3 MOSFET_NSI4778DY
D301 5V /SEPIC Converter/VOUT SL44-E3_57TDIODE_DO214AB-M
CIN301 /Charger/V+ToBoost GND 3.3uF
CIN302 /Charger/V+ToBoost GND 3.3uF
TP301 /Charger/V+CH Charger+
J302 5V GND 5V GND 5V GND 5V GND 5V GND 5V GND 5V GND NC_01 GND NC_02 /Charger/VBATT /Charger/CHG_CON /Charger/CHSTAT 2X10-2MMSMD
TP302 /Charger/CHSTAT ChStat
.end
