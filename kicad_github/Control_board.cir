.title KiCad schematic
R5 +3V3 /SCL 10K
R7 +3V3 /SDA 10K
LS1 +3V3 Net-_LS1-Pad2_ PS1240P02BT
R6 +3V3 Net-_C7-Pad1_ 100K
C3 GND +5V 1uF
Q5 /airstone_pump Net-_J4-Pad2_ GND Net-_J4-Pad2_ BSP76_E6433
Q3 /pump Net-_J3-Pad2_ GND Net-_J3-Pad2_ BSP76_E6433
D2 GND Net-_D2-Pad2_ LED
R12 /pump Net-_D2-Pad2_ 1k
D1 GND Net-_D1-Pad2_ LED
R11 /airstone_pump Net-_D1-Pad2_ 1k
IC2 +3V3 /SDA /EN /SCL GND /DSCL- /DSCL+ /DSDA+ /DSDA- +5V PCA9615DPJ
R3 +5V /DSDA+ 390
R10 /DSDA- GND 390
R9 /DSDA+ /DSDA- 100
R16 +5V /DSCL+ 390
R18 /DSCL- GND 390
R17 /DSCL+ /DSCL- 100
J6 /DSCL- /DSCL+ NC_01 +3V3 GND NC_02 /DSDA- /DSDA+ RJ45
C5 GND +5V 1uF
C4 +3V3 GND 0.1uF
J11 GND +3V3 /SDA /SCL Conn_01x04
J12 GND +3V3 /SDA /SCL Conn_01x04
J13 /Touch Conn_01x01_Female
J4 +12V Net-_J4-Pad2_ 43045-0200
J3 +12V Net-_J3-Pad2_ 43045-0200
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
R14 /ADJ_LED2 Net-_C2-Pad1_ 1k
R15 Net-_D5-Pad3_ GND 10K
R20 /ADJ_LED3 Net-_C6-Pad1_ 1k
R21 Net-_C7-Pad1_ /LDR 100
C7 Net-_C7-Pad1_ GND 100nF
R19 Net-_D9-Pad3_ GND 10K
R22 +3V3 Net-_J5-Pad2_ 4.7k
Q2 Net-_Q2-Pad1_ GND Net-_LS1-Pad2_ BSS138-Transistor_FET
R2 /buzzer Net-_Q2-Pad1_ 10K
J7 GND /ADJ_LED3 /NTC_3 +48V /12V_Fan +3V3 66200621022
J2 GND /ADJ_LED2 /NTC_2 +48V /12V_Fan +3V3 66200621022
IC1 Net-_IC1-Pad1_ NC_03 GND NC_04 +12V /12V_Fan /12V_Fan +12V VN7050ASTR
R1 /fan Net-_D3-Pad2_ 1k
D3 GND Net-_D3-Pad2_ LED
R23 Net-_IC1-Pad1_ /fan 15k
IC3 NC_05 Net-_IC3-Pad2_ GND Net-_IC3-Pad4_ /1-Wire PSSI2021SAY,115
R24 Net-_IC3-Pad2_ GND 39k
Q1 Net-_IC3-Pad2_ Net-_J5-Pad2_ /1-Wire Q_NMOS_GSD
R25 /1-Wire Net-_IC3-Pad4_ 10k
U2 GND +5V +12V NCP1117-5.0_TO252
Q4 Net-_Q4-Pad1_ Net-_D10-Pad1_ +48V Q_PMOS_GDS
R31 Net-_Q4-Pad1_ GND 100k
F1 Net-_D10-Pad1_ VCC Polyfuse
D10 Net-_D10-Pad1_ GND SMF60A
R29 +3V3 Net-_R29-Pad2_ 10K
S2 Net-_R29-Pad2_ GND FSM8JRT
S1 GND Net-_R28-Pad2_ FSM8JRT
R28 +3V3 Net-_R28-Pad2_ 10K
R8 /ADJ_LED1 Net-_C1-Pad1_ 1k
R13 Net-_D4-Pad3_ GND 10K
R26 Net-_D4-Pad3_ /NTC_3 1k
R27 Net-_D5-Pad3_ /NTC_2 1k
C1 Net-_C1-Pad1_ GND 0.1uF
C2 Net-_C2-Pad1_ GND 0.1uF
C6 Net-_C6-Pad1_ GND 0.1uF
R30 /NTC_1 Net-_D9-Pad3_ 1k
Z11 GND +48V BZX84C8V2LT1G
U3 +12V +12V +12V +12V GND GND +48V +48V NC_06 NC_07 NC_08 NID35-12_meanwell
R35 Net-_J10-Pad2_ Net-_J5-Pad2_ DNP
U1 Net-_D11-Pad1_ NC_09 NC_10 NC_11 NC_12 Net-_R28-Pad2_ Net-_D4-Pad3_ Net-_D5-Pad3_ /fan /1-Wire /EN /Spare /buzzer GND /pump NC_13 NC_14 NC_15 +5V GND /SDA /SCL NC_16 NC_17 Net-_R29-Pad2_ GND Net-_D9-Pad3_ Net-_C1-Pad1_ /airstone_pump NC_18 NC_19 /Touch /LDR Net-_C2-Pad1_ Net-_C6-Pad1_ NC_20 NC_21 NC_22 ESP32-DEVKITC-32D
R32 +3V3 /Spare DNP
R33 /Spare GND DNP
J8 VCC GND TB003-500-P02BE
Q6 Net-_C7-Pad1_ GND Q_Photo_NPN
J10 +3V3 Net-_J10-Pad2_ GND Net-_J10-Pad4_ 43045-0401_2
J1 GND /ADJ_LED1 /NTC_1 +48V /12V_Fan +3V3 66200621022
J5 +3V3 Net-_J5-Pad2_ GND NC_23 43045-0401_2
D4 GND +3V3 Net-_D4-Pad3_ BAT54SLT1G
D5 GND +3V3 Net-_D5-Pad3_ BAT54SLT1G
D8 GND +3V3 Net-_C6-Pad1_ BAT54SLT1G
D7 GND +3V3 Net-_C2-Pad1_ BAT54SLT1G
D6 GND +3V3 Net-_C1-Pad1_ BAT54SLT1G
D9 GND +3V3 Net-_D9-Pad3_ BAT54SLT1G
D11 Net-_D11-Pad1_ NC_24 +3V3 BAT54W
R4 +12V Net-_J10-Pad4_ DNP
R34 /Spare Net-_J10-Pad2_ DNP
.end
