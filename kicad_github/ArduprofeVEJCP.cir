.title KiCad schematic
C3 GND /C3 22pf
Y1 /C3 /C4 XL
C4 /C4 GND 22pf
R2 RST +5V 10K
J3 +30V -30V Conn_01x02_Female
CON1 NC IOREF RST +3V3 +5V GND GND VIN AIN0 AIN1 AIN2 AIN3 SDA SCL RX TX D2 PWM3 D4 PWM5 PWM6 D7 D8 PWM9 PWM10 PWM11 D12 D13 GND AREF SDA SCL SheldArduino
CONN4 NC IOREF RST +3V3 +5V GND GND VIN AIN0 AIN1 AIN2 AIN3 SDA SCL RX TX D2 PWM3 D4 PWM5 PWM6 D7 D8 PWM9 PWM10 PWM11 D12 D13 GND AREF SDA SCL ArduinoSheldExt
R7 /L10 PWM10 1K
R8 /L11 PWM11 1K
R9 /L12 D12 1K
R10 /L13 D13 1K
R4 +5V /LON 1K
JP3 Net-_JP3-Pad1_ GND MOTOR
R3 /LDR +5V 100K
JP2 /LDR AIN0 A0
C5 DT RST 0.1uf
Relay1 /QE C +5V /RNC /RNA SRD_05VD
Q1 GND /QB /QE 2222A
R1 /QB /RL 10K
D3 /LED /L9 L9
D4 /LED /L10 L10
D5 /LED /L11 L11
D6 /LED /L12 L12
R6 /L9 PWM9 1K
D7 /LED /L13 L13
D2 GND /LON ON
CONN9 /M15 /M16 /M29 /M210 MOTOR
U4 +5V PWM6 /M16 GND GND /M15 PWM5 Net-_JP3-Pad1_ +5V PWM9 /M29 GND GND /M210 PWM10 +5V L293D
JP4 +5V +S Servos
R5 GND /LDR LDR-A0
JP1 /RL D12 Relay
MOD3 NC_01 +5V GND RX TX NC_02 HC-05_06
MOD4 GND +5V RX TX DT Net-_J2-Pad1_ CH340E
U1 RST RX TX D2 PWM3 D4 +5V GND /C3 /C4 PWM5 PWM6 D7 D8 PWM9 PWM10 PWM11 D12 D13 +5V AREF GND AIN0 AIN1 AIN2 AIN3 SDA SCL ATmega328P-PU
CONN2 GND +S D4 S1
CONN3 GND +S D7 S2
CONN5 GND +S D8 S3
Sw1 RST GND RESET
MOD2 GND D2 PWM3 +5V HC-SR04
SEN1 D2 GND +5V IR1838B
JP5 /LED GND LED
D1 +5V /QE 1N4004
CONN7 /RNA C /RNC Bornera_5.0_3P
MOD1 TX1 CH RS 3V3 RX1 IO0 IO2 GND ESP8266
CONN6 TX1 CH RS 3V3 RX1 IO0 IO2 GND ESP8266
CONN8 D13 D12 PWM11 GND +5V Max7219_8x8>>
C2 Reg GND 0.1uf
C1 PR GND 0.33uf
U2 PR GND Reg L7805
LCD1 GND +5V SDA SCL LCD_I2C1604
J1 +5V GND Conn_01x02_Female
JP6 Reg +5V REG
U5 +30V PR -30V GND 2W10_2A
J2 Net-_J2-Pad1_ 3V3
U8 /OF1 /INA GND1 VCC- /OF2 /OUTA VCC+ NC_03 TL081
RV3 /OF2 /RPT /OF1 100K
R17 /RPT VCC- 1.5K
J8 GND1 VCC+ VCC- Conn_01x03_Female
R16 /INA /OUTA 1K
J6 /OUTA OUT
J5 /INA IN
U7 GND2 /Q2E /SSAL NC_04 NC_05 /C8 /R18 /J412V NE555
R18 /R18 /J412V 1K
C8 /C8 GND2 47uf
R19 /SAL /SSAL 1K
R13 /J412V /Q2E 100K
Q2 GND2 /Q2B /Q2E 2222A
R12 /Q2B /M+ 1K
R11 /M+ /RV1 10K
RV1 NC_06 /RV1 /J412V 100K
J4 GND2 /J412V 12V
J7 /SAL SAL
M1 GND2 /M+ MIC
CONN1 D12 +5V D13 PWM11 RST GND ICSP
U3 -3 4 GND3 VC+ GND3 VC+ XT1 XT2 -5 -6 7 8 -9 -10 -11 12 13 VC+ AD6 ARF GND3 AD7 AN0 AN1 AN2 AN3 AN4 AN5 RS1 TX2 RX2 NC_07 ATmega328-AU
Y2 XT1 XT2 XL
C6 GND3 XT1 22p
C7 GND3 XT2 22p
U6 OF1 INS GND3 V- OF2 OUTS V+ NC_08 TL081
RV2 OF2 /Micro328U/PV OF1 R_POT
R20 /Micro328U/PV V- 1.5K
R15 OUTS INS 1K
R14 VC+ RS1 1K
J11 -6 7 8 -9 -10 -11 12 DIGITAL
J10 13 ARF AD6 AD7 AN0 AN1 AN2 DIGITAL
J12 -5 4 -3 RX2 TX2 GND3 GND3 Alimentacion
J9 V- VC+ V+ RS1 AN5 AN4 AN3 ANALOG
J13 OUTS INS Conn_01x02_Female
.end
