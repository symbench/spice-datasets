.title KiCad schematic
C6 +3V3 GNDREF 0.1uF
C7 +3V3 GNDREF 0.1uF
C8 +3V3 GNDREF 0.1uF
C10 +3V3 GNDREF 0.1uF
L1 Net-_C12-Pad1_ +3V3 Ferrite_Bead
C9 Net-_C12-Pad1_ GNDREF 10uF
C12 Net-_C12-Pad1_ GNDREF 0.01uF
C13 Net-_C12-Pad1_ GNDREF 0.01uF
C5 +3V3 GNDREF 10uF
C14 Net-_C14-Pad1_ GNDREF 1uF
R1 +3V3 /~EFM_RESET 100k
SW1 /~EFM_RESET Net-_R2-Pad1_ SW_Push
C1 /~EFM_RESET GNDREF 0.1uF
R2 Net-_R2-Pad1_ GNDREF 100
C15 Net-_C15-Pad1_ GNDREF 1uF
C11 Net-_C11-Pad1_ GNDREF 4.7uF
R5 Net-_C11-Pad1_ VBUS 0
U1 GNDREF +3V3 VBUS +3V3 AZ1117CH-3_3TRG1
C2 VBUS GNDREF 10uF
C3 +3V3 GNDREF 10uF
C4 +3V3 GNDREF 10uF
J3 VBUS +3V3 /PA0 /PC0 /PA1 /PC1 /PA2 /PC2 /PA8 /PC3 /PA9 /PC4 /PA10 /PC8 /PB7 /PC9 /PB8 /PC10 /PB11 /PC14 /PB13 /PC15 /PB14 /PD4 /PE10 /PD5 /PE11 /PD6 /PE12 /PD7 /PE13 NC_01 NC_02 NC_03 NC_04 GNDREF Conn_02x18_Odd_Even
U2 /PA0 /PA1 /PA2 +3V3 GNDREF /PC0 /PC1 /PC2 /PC3 /PC4 /RTCP /RTCM /PA8 /PA9 /PA10 /~EFM_RESET /PB11 GNDREF Net-_C12-Pad1_ /XTALP /XTALM +3V3 Net-_C12-Pad1_ /PD4 /PD5 /PD6 /PD7 +3V3 Net-_C14-Pad1_ /PC8 /PC9 /PC10 Net-_C11-Pad1_ Net-_C15-Pad1_ /USB_DM /USB_DP /DBG_SWCLK /DBG_SWDIO /LED0 /LED1 /SW0 /SW1 +3V3 GNDREF /PE10 /PE11 /PE12 /PE13 EFM32HG322F64
SW2 /SW0 GNDREF SW_Push
SW3 /SW1 GNDREF SW_Push
R11 +3V3 /SW0 47k
R13 +3V3 /SW1 47k
R10 Net-_D1-Pad2_ /LED0 100
R12 Net-_D2-Pad2_ /LED1 100
D1 +3V3 Net-_D1-Pad2_ 2.1V
D2 +3V3 Net-_D2-Pad2_ 2.1V
R3 /PC14 /USB_DM 10
R4 /PC15 /USB_DP 10
D3 +3V3 Net-_D3-Pad2_ 2.1V
R14 Net-_D3-Pad2_ GNDREF 100
TP2 Net-_J2-Pad4_ TestPoint
TP1 /~EFM_RESET TestPoint
C16 /XTALM GNDREF 22pF
C18 /XTALP GNDREF 22pF
C17 /RTCM GNDREF 22pF
C19 /RTCP GNDREF 22pF
R8 /PB7 /RTCP 0
R9 /PB8 /RTCM 0
Y2 /RTCM /RTCP GNDREF Crystal_GND3
R7 /PB14 /XTALM 0
R6 /PB13 /XTALP 0
J2 VBUS /USB_DM /USB_DP Net-_J2-Pad4_ GNDREF GNDREF UJ2-MBH-1-SMT-TR
J1 +3V3 /DBG_SWDIO GNDREF /DBG_SWCLK GNDREF NC_05 NC_06 NC_07 GNDREF /~EFM_RESET Conn_02x05_Odd_Even
Y1 /XTALM GNDREF /XTALP GNDREF Crystal_GND24
.end
