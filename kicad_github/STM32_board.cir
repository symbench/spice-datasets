.title KiCad schematic
U1 /5V /P_AH_OUT /P_AH /P_BH_OUT /P_BH /P_CH_OUT /P_CH /GND /P_AL /P_AL_OUT /P_BL /P_BL_OUT NC_01 /P_CL /P_CL_OUT NC_02 CD4050BE
TB1 /GND /GND Net-_TB1-PadP1_3_ Net-_TB1-PadP1_3_ /GND NC_03 NC_04 /JoystickADC1 NC_05 /JoystickADC2 NC_06 /JoystickButton /EXT_1 /EXT_0 NC_07 /EXT_2 NC_08 /CURRENT_SENSOR NC_09 /ADC_BATTERY NC_10 /READ_BATTERY /GND NC_11 /LcdRS /EXT_5 /LcdEN /EXT_6 /LcdD4 /EXT_7 /LcdD5 NC_12 /LcdD6 NC_13 /LcdD7 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 Net-_D1-Pad2_ NC_21 Net-_D2-Pad2_ NC_22 Net-_D3-Pad2_ /GND /GND /GND /GND /5V /5V /3V /3V NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 /P_CH NC_36 Net-_TB1-PadP1_3_ NC_37 /P_BH NC_38 /P_AH NC_39 NC_40 NC_41 NC_42 NC_43 /P_CL NC_44 /P_BL NC_45 /P_AL /UART1_TX /UART2_RX NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 /EXT_3 NC_52 /EXT_4 NC_53 /GND /GND STM32F4DISCOVERY
U2 /12V /GND /5V LM7805_TO220
J1 /12V /GND Power connector
C1 /12V /GND CP
C2 /5V /GND C
U3 /3V3 /GND /5V LP2950-3.3_TO92
C4 /3V3 /GND C4
J4 /GND /5V /V0 /LcdRS /GND /LcdEN /GND /GND /GND /GND /LcdD4 /LcdD5 /LcdD6 /LcdD7 /5V /GND LCD interface
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ LED
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ LED
R1 /GND Net-_D1-Pad1_ R
R2 /GND Net-_D2-Pad1_ R
R3 /GND Net-_D3-Pad1_ R
J2 /P_AH_OUT /P_BH_OUT /P_CH_OUT High side connector
J5 /P_AL_OUT /P_BL_OUT /P_CL_OUT Low side connector
J6 /3V3 /GND 3v3_out
RV1 /5V /V0 /GND R_POT
J7 /GND /3V /JoystickADC1 /JoystickADC2 /JoystickButton Joystick connector
C3 /5V /GND C3
J9 NC_54 /UART2_RX /UART1_TX NC_55 NC_56 /GND UART module
R4 /3V /JoystickButton R
J10 /EXT_0 /EXT_1 /EXT_2 Low side connector
J3 /CURRENT_SENSOR /ADC_BATTERY /READ_BATTERY Sensors connector
J8 /EXT_5 /EXT_6 /EXT_7 Output pins
J11 /GND /EXT_4 /EXT_3 Output pins
.end
