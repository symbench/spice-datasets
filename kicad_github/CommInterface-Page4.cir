.title KiCad schematic
U7 RXD1 DIR1 DIR1 TXD1 GND NC_01 NC_02 +5V MAX485E
C14 +5V GND C
U8 RXD2 DIR2 DIR2 TXD2 GND NC_03 NC_04 +5V MAX485E
C15 +5V GND C
U9 RXD3 DIR3 DIR3 TXD3 GND 485A3 485B3 +5V MAX485E
C16 +5V GND C
R20 Net-_D3-Pad2_ +5V R
D3 RXD1 Net-_D3-Pad2_ LED
R21 Net-_D4-Pad2_ +5V R
D4 TXD1 Net-_D4-Pad2_ LED
R22 Net-_D5-Pad2_ +5V R
D5 RXD2 Net-_D5-Pad2_ LED
R23 Net-_D6-Pad2_ +5V R
D6 TXD2 Net-_D6-Pad2_ LED
R24 Net-_D7-Pad2_ +5V R
D7 RXD3 Net-_D7-Pad2_ LED
R25 Net-_D8-Pad2_ +5V R
D8 TXD3 Net-_D8-Pad2_ LED
U10 SpdRXD xxxxxxxxxx xxxxxxxxxx SpdTXD GND 485A3 485B3 +5V MAX485E
C17 +5V GND C
R26 Net-_D9-Pad2_ +5V R
D9 SpdRXD Net-_D9-Pad2_ LED
R27 Net-_D10-Pad2_ +5V R
D10 SpdTXD Net-_D10-Pad2_ LED
U1 +5V NC_05 NC_06 NC_07 GND NC_08 NC_09 Net-_C9-Pad1_ Net-_C5-Pad1_ GND NC_10 NC_11 NC_12 rSCK rMOSI rMISO NC_13 Net-_C2-Pad1_ +5V Net-_U1-Pad20_ Net-_U1-Pad21_ NC_14 NC_15 Net-_U1-Pad20_ NC_16 GND +5V Net-_U1-Pad21_ MCP25625-x-SS
C2 Net-_C2-Pad1_ GND C
C1 +5V GND C
R1 Net-_C2-Pad1_ +5V R
C5 Net-_C5-Pad1_ GND C
C9 Net-_C9-Pad1_ GND C
Y1 Net-_C5-Pad1_ Net-_C9-Pad1_ Crystal
J1 Net-_J1-Pad1_ Net-_C3-Pad1_ Net-_C4-Pad1_ Net-_C3-Pad2_ Net-_J1-Pad5_ USB_B
U2 Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_C8-Pad1_ Net-_U2-Pad4_ Net-_C3-Pad2_ NC_17 Net-_D2-Pad1_ Net-_R4-Pad2_ Net-_R3-Pad2_ Net-_C8-Pad1_ Net-_C8-Pad1_ +5V Net-_C3-Pad2_ Net-_D1-Pad1_ Net-_J2-Pad1_ Net-_R5-Pad2_ FT230XS
R7 Net-_D1-Pad2_ Net-_C8-Pad1_ R
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ LED
R8 Net-_D2-Pad2_ Net-_C8-Pad1_ R
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED
R5 Net-_J1-Pad1_ Net-_R5-Pad2_ R
R6 Net-_R5-Pad2_ Net-_C3-Pad2_ R
R4 Net-_C4-Pad1_ Net-_R4-Pad2_ R
R3 Net-_C3-Pad1_ Net-_R3-Pad2_ R
C8 Net-_C8-Pad1_ Net-_C3-Pad2_ C
C4 Net-_C4-Pad1_ Net-_C3-Pad2_ C
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ C
C7 +5V Net-_C3-Pad2_ C
C6 +5V Net-_C3-Pad2_ CP
R2 Net-_C3-Pad2_ Net-_J1-Pad5_ R
U3 Net-_J2-Pad1_ +5V GND SpdRXD Net-_U2-Pad1_ NC_18 ADG779
C11 GND +5V C
R9 +5V Net-_J2-Pad1_ R
U4 Net-_J2-Pad1_ +5V GND SpdTXD Net-_U2-Pad4_ NC_19 ADG779
C12 GND +5V C
U5 Net-_J2-Pad1_ +5V GND NC_20 Net-_U2-Pad2_ NC_21 ADG779
C13 GND +5V C
J2 Net-_J2-Pad1_ Net-_C3-Pad2_ Conn_01x02
J3 NC_22 3V3ssSD 3V3MOSI +3V3 3V3SCK GND 3V3MISO NC_23 NC_24 Micro_SD_Card
Q3 3V3MISO rMISO 3V3MISO Q_NMOS_GDS
Q2 3V3SCK rSCK 3V3SCK Q_NMOS_GDS
Q1 3V3MOSI rMOSI 3V3MOSI Q_NMOS_GDS
R12 rMISO +5V R
R11 rSCK +5V R
R10 rMOSI +5V R
R15 +3V3 3V3MOSI R
R16 +3V3 3V3SCK R
R17 +3V3 3V3MISO R
Q4 3V3ssSD D54 3V3ssSD Q_NMOS_GDS
R13 D54 +5V R
R18 +3V3 3V3ssSD R
Q5 3V3ssFlash D55 3V3ssFlash Q_NMOS_GDS
R14 D55 +5V R
R19 +3V3 3V3ssFlash R
C10 +3V3 GND C
U6 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 M25PX32-VMW
.end
