.title KiCad schematic
J1 /RF_IN /RF_OUT /VIN_AC /VIN_GND term_block_4-pin
C1 /RF_IN Net-_C1-Pad2_ CAP_0603
R2 +5V Net-_C1-Pad2_ RES_0603
R1 Net-_C1-Pad2_ GND RES_0603
Q1 Net-_C1-Pad2_ Net-_D4-PadA_ +5V NPN
R3 Net-_D4-PadA_ GND RES_0603
D4 Net-_D4-PadA_ Net-_C2-Pad1_ Diode_SMA
C4 Net-_C2-Pad1_ Net-_C4-Pad2_ CAP_0603
C2 Net-_C2-Pad1_ GND CAP_0603
R6 Net-_C2-Pad1_ GND RES_0603
D5 GND Net-_C4-Pad2_ Diode_SMA
R8 Net-_C6-Pad1_ Net-_C4-Pad2_ RES_0603
C6 Net-_C6-Pad1_ GND CAP_0603
Q4 Net-_C6-Pad1_ GND Net-_Q4-Pad3_ NPN
R11 +3V3 Net-_Q4-Pad3_ RES_0603
R13 Net-_Q7-Pad1_ Net-_Q4-Pad3_ RES_0603
R19 Net-_Q7-Pad3_ GND RES_0603
Q7 Net-_Q7-Pad1_ +3V3 Net-_Q7-Pad3_ PNP
R21 /UART_RX Net-_Q7-Pad3_ RES_0603
D1 GND Net-_C1-Pad2_ Zener_SMA
J3 /MCLR Net-_J3-Pad2_ GND /ICSPDAT /ICSPCLK NC_01 HEADER_1X6
R28 Net-_R28-Pad1_ /ICSPDAT RES_0603
R29 Net-_R29-Pad1_ /ICSPCLK RES_0603
R22 Net-_C9-Pad1_ +3V3 RES_0603
C7 GND +3V3 CAP_0603
C9 Net-_C9-Pad1_ GND CAP_0603
U3 +3V3 /GPIO3 /CLKOUT /MCLR /UART_RX /UART_TX /SW_1 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 /GPIO2 /GPIO1 /AN4 /V_Temp Net-_R29-Pad1_ Net-_R28-Pad1_ GND PIC16F1829_SOIC
D9 Net-_C9-Pad1_ /MCLR Schottky_SMA
R25 +3V3 Net-_J3-Pad2_ RES_0603
U4 +5V Net-_R24-Pad2_ GND Temp_SOT23-3
C8 GND +5V CAP_0603
R24 /V_Temp Net-_R24-Pad2_ RES_0603
R23 /V_Temp GND RES_0603
U5 NC_08 +5V GND Net-_R26-Pad1_ NC_09 NC_10 NC_11 NC_12 MPX5100
C10 GND +5V CAP_0603
R26 Net-_R26-Pad1_ /AN4 RES_0603
R27 /AN4 GND RES_0603
U1 +5V NC_13 /VIN_AC /SW_24V_1 /SW_24V_2 /VIN_AC NC_14 Net-_D3-PadA_ Relay-EC2-5NU
D3 Net-_D3-PadA_ +5V Schottky_SMA
Q2 Net-_D3-PadA_ Net-_Q2-PadG_ GND MOSFET-N
R5 Net-_Q2-PadG_ /SW_1 RES_0603
R4 Net-_D3-PadA_ Net-_D2-PadC_ RES_0603
J2 /SW_24V_1 /VIN_GND /SW_24V_2 /VIN_GND term_block_4-pin
D2 +5V Net-_D2-PadC_ LED_0603
U2 Net-_Q5-Pad3_ /CLKOUT GND Net-_R7-Pad2_ +5V NC7SZ125
R7 Net-_C3-Pad1_ Net-_R7-Pad2_ RES_0603
Q5 Net-_Q5-Pad1_ GND Net-_Q5-Pad3_ NPN
R18 Net-_Q5-Pad1_ /UART_TX RES_0603
R14 +5V Net-_Q5-Pad3_ RES_0603
R16 Net-_Q5-Pad3_ /UART_TX RES_0603
C5 +5V GND CAP_0603
C3 Net-_C3-Pad1_ /RF_OUT CAP_0603
R10 Net-_D6-PadC_ Net-_Q3-PadD_ RES_0603
Q3 Net-_Q3-PadD_ Net-_Q3-PadG_ GND MOSFET-N
D6 +5V Net-_D6-PadC_ LED_0603
R9 Net-_Q3-PadG_ /GPIO1 RES_0603
R15 Net-_D7-PadC_ Net-_Q6-PadD_ RES_0603
Q6 Net-_Q6-PadD_ Net-_Q6-PadG_ GND MOSFET-N
D7 +5V Net-_D7-PadC_ LED_0603
R12 Net-_Q6-PadG_ /GPIO2 RES_0603
R20 Net-_D8-PadC_ Net-_Q8-PadD_ RES_0603
Q8 Net-_Q8-PadD_ Net-_Q8-PadG_ GND MOSFET-N
D8 +5V Net-_D8-PadC_ LED_0603
R17 Net-_Q8-PadG_ /GPIO3 RES_0603
M1 GND MNT-3MM
M2 GND MNT-3MM
M3 GND MNT-3MM
M4 GND MNT-3MM
D18 GND Net-_C3-Pad1_ Zener_SMA
U7 GND +3V3 +5V +3V3 TLV1117_3.3V
C15 +3V3 GND CAP_ELEC
C16 +3V3 GND CAP_0805
C14 +5V GND CAP_0805
C11 /Power/VIN GND CAP_ELEC
D11 /VIN_AC /Power/VIN Diode_SMB
D13 /VIN_GND /Power/VIN Diode_SMB
D10 GND /VIN_AC Diode_SMB
D12 GND /VIN_GND Diode_SMB
C13 +5V GND CAP_ELEC
U6 Net-_R33-Pad2_ Net-_D14-PadC_ Net-_C12-Pad1_ GND Net-_R31-Pad2_ /Power/VIN Net-_R33-Pad2_ Net-_R33-Pad2_ MC34063A_buck
R32 GND Net-_R31-Pad2_ RES_0603
R31 +5V Net-_R31-Pad2_ RES_0603
D14 GND Net-_D14-PadC_ Schottky_SMA
L1 Net-_D14-PadC_ +5V IND
C12 Net-_C12-Pad1_ GND CAP_0603
D15 +5V Net-_D15-PadC_ LED_0603
R34 GND Net-_D15-PadC_ RES_0603
R35 GND Net-_D17-PadC_ RES_0603
R30 /VIN_GND GND RES_0805
D17 +3V3 Net-_D17-PadC_ LED_0603
D16 +3V3 +5V Diode_SMB
R33 /Power/VIN Net-_R33-Pad2_ RES_0805
.end
