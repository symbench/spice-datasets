.title KiCad schematic
C319 NC_01 Net-_C319-Pad2_ C
C321 NC_02 Net-_C319-Pad2_ C
C320 Net-_C320-Pad1_ NC_03 C
C322 Net-_C320-Pad1_ NC_04 C
J90 Net-_C319-Pad2_ NC_05 Net-_J90-Pad3_ Net-_J90-Pad3_ NC_06 Net-_C320-Pad1_ InConnector
J91 NC_07 NC_08 Net-_J91-Pad3_ Net-_J91-Pad3_ NC_09 NC_10 OutConnector
R383 Net-_R382-Pad2_ Net-_J91-Pad3_ R
R380 NC_11 Net-_R379-Pad2_ R
R381 Net-_R379-Pad2_ Net-_J91-Pad3_ R
R382 Net-_R379-Pad2_ Net-_R382-Pad2_ R
R379 Net-_R376-Pad2_ Net-_R379-Pad2_ R
R378 NC_12 Net-_R377-Pad2_ R
R376 Net-_R375-Pad2_ Net-_R376-Pad2_ R
R377 Net-_R375-Pad2_ Net-_R377-Pad2_ R
R375 Net-_J90-Pad3_ Net-_R375-Pad2_ R
U4 Net-_J91-Pad3_ NC_13 Net-_R382-Pad2_ NC_14 Net-_R377-Pad2_ Net-_R376-Pad2_ Net-_R376-Pad2_ NC_15 ADA4075-2
C17 NC_16 Net-_C17-Pad2_ C
C19 NC_17 Net-_C17-Pad2_ C
C18 Net-_C18-Pad1_ NC_18 C
C20 Net-_C18-Pad1_ NC_19 C
J10 Net-_C17-Pad2_ NC_20 Net-_J10-Pad3_ Net-_J10-Pad4_ NC_21 Net-_C18-Pad1_ InConnector
J11 Net-_C37-Pad2_ NC_22 Net-_J11-Pad3_ Net-_J11-Pad4_ NC_23 Net-_C38-Pad1_ OutConnector
R37 Net-_R34-Pad2_ Net-_J11-Pad3_ R
R31 NC_24 Net-_R29-Pad2_ R
R33 Net-_R29-Pad2_ Net-_J11-Pad3_ R
R34 Net-_R29-Pad2_ Net-_R34-Pad2_ R
R29 Net-_R23-Pad2_ Net-_R29-Pad2_ R
R27 NC_25 Net-_R24-Pad2_ R
R23 Net-_R21-Pad2_ Net-_R23-Pad2_ R
R24 Net-_R21-Pad2_ Net-_R24-Pad2_ R
R21 Net-_J10-Pad3_ Net-_R21-Pad2_ R
R38 Net-_R36-Pad2_ Net-_J11-Pad4_ R
R32 NC_26 Net-_R30-Pad2_ R
R35 Net-_R30-Pad2_ Net-_J11-Pad4_ R
R36 Net-_R30-Pad2_ Net-_R36-Pad2_ R
R30 Net-_R25-Pad2_ Net-_R30-Pad2_ R
R28 NC_27 Net-_R26-Pad2_ R
R25 Net-_R22-Pad2_ Net-_R25-Pad2_ R
R26 Net-_R22-Pad2_ Net-_R26-Pad2_ R
R22 Net-_J10-Pad4_ Net-_R22-Pad2_ R
U9 Net-_J11-Pad3_ NC_28 Net-_R34-Pad2_ NC_29 Net-_R24-Pad2_ Net-_R23-Pad2_ Net-_R23-Pad2_ NC_30 ADA4075-2
U10 Net-_J11-Pad4_ NC_31 Net-_R36-Pad2_ NC_32 Net-_R26-Pad2_ Net-_R25-Pad2_ Net-_R25-Pad2_ NC_33 ADA4075-2
C39 NC_34 Net-_C37-Pad2_ C
C37 NC_35 Net-_C37-Pad2_ C
C40 Net-_C38-Pad1_ NC_36 C
C38 Net-_C38-Pad1_ NC_37 C
.end
