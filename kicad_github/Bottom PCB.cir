.title KiCad schematic
R104 GND SwFR 10k
R101 GND SwFL 10k
SW102 +3V3 SwFR NC_01 FR
SW101 +3V3 SwFL NC_02 FL
Logo101 SquashedFlyLogo
U104 Net-_R107-Pad1_ GND OpML GND QRE1113
U105 Net-_R112-Pad1_ GND OpMR GND QRE1113
U101 Net-_R105-Pad1_ GND OpFL GND QRE1113
R106 OpFL +3V3 10k
R105 Net-_R105-Pad1_ IR 100
C101 OpFL GND 100pF
R108 OpML +3V3 10k
R107 Net-_R107-Pad1_ IR 100
C106 OpML GND 100pF
R113 OpMR +3V3 10k
R112 Net-_R112-Pad1_ IR 100
C107 OpMR GND 100pF
C102 +5V GND 100pF
C104 +5V GND 100pF
C103 +5V GND 10uF
C105 +5V GND 10uF
C108 OpFR GND 100pF
R114 Net-_R114-Pad1_ IR 100
R115 OpFR +3V3 10k
U106 Net-_R114-Pad1_ GND OpFR GND QRE1113
JP103 Net-_JP103-Pad1_ GND A0
JP102 Net-_JP102-Pad1_ GND A1
JP101 Net-_JP101-Pad1_ GND A2
R109 Net-_JP101-Pad1_ +3V3 47k
R110 Net-_JP102-Pad1_ +3V3 47k
R111 Net-_JP103-Pad1_ +3V3 47k
U103 Net-_U102-Pad8_ Net-_U102-Pad7_ Net-_U102-Pad6_ Net-_U102-Pad5_ Net-_U102-Pad4_ Net-_U102-Pad3_ Net-_U102-Pad2_ Net-_U102-Pad1_ +3V3 GND NC_03 SCL SDA NC_04 Net-_JP103-Pad1_ Net-_JP102-Pad1_ Net-_JP101-Pad1_ +3V3 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 MCP23017_SO
U102 Net-_U102-Pad1_ Net-_U102-Pad2_ Net-_U102-Pad3_ Net-_U102-Pad4_ Net-_U102-Pad5_ Net-_U102-Pad6_ Net-_U102-Pad7_ Net-_U102-Pad8_ GND +5V Net-_J102-Pad2_ Net-_J102-Pad3_ Net-_J102-Pad4_ Net-_J102-Pad5_ Net-_J101-Pad5_ Net-_J101-Pad4_ Net-_J101-Pad3_ Net-_J101-Pad2_ ULN2003A
J102 +5V Net-_J102-Pad2_ Net-_J102-Pad3_ Net-_J102-Pad4_ Net-_J102-Pad5_ Steper2
J101 +5V Net-_J101-Pad2_ Net-_J101-Pad3_ Net-_J101-Pad4_ Net-_J101-Pad5_ Steper1
HC-SR101 +5V Sonar_Trig Net-_HC-SR101-Pad3_ GND HC-SR04
R102 Sonar_Echo Net-_HC-SR101-Pad3_ 2k7
R103 Sonar_Echo GND 4k7
U201 GND +3V3 EN half_BatV BatV Sonar_Echo Sonar_Trig NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 GND NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 GPIO0 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 SCL RX TX SDA NC_38 GND GND ESP32-WROVER
Q202 Net-_Q202-Pad1_ /ESP32-WROVER/DTR GPIO0 BC847
Q201 Net-_Q201-Pad1_ /ESP32-WROVER/CTS EN BC847
R203 /ESP32-WROVER/DTR Net-_Q201-Pad1_ 10K
R204 /ESP32-WROVER/CTS Net-_Q202-Pad1_ 10K
J201 GND /ESP32-WROVER/CTS +3V3 RX TX /ESP32-WROVER/DTR PROGRAMMING
C204 +3V3 GND 100pF
C201 +3V3 GND 10uF
C202 +3V3 GND 10uF
C203 +3V3 GND 100pF
R201 +3V3 SDA 4K7
R202 +3V3 SCL 4k7
J202 NC_39 +5V GND TX RX GND MainIO
R303 GND BatV 10k
R301 BatV +BATT 47k
R304 GND half_BatV 10k
R302 half_BatV half_Bat 47k
C306 half_BatV GND 10uF
J301 /Bat Managment/PowerIn half_Bat half_Bat GND Battery
U301 +BATT GND +5V MC78M05_TO252
C302 +BATT GND 10uF
C301 +BATT GND 100pF
C303 +5V GND 10uF
C304 +5V GND 100pF
SW301 /Bat Managment/PowerIn +BATT SW_SPST
C305 BatV GND 10uF
D301 Net-_D301-Pad1_ +BATT Power
R305 GND Net-_D301-Pad1_ 470
.end
