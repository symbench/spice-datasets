.title KiCad schematic
U4 Net-_C8-Pad1_ /MD Net-_R21-Pad1_ Net-_U4-Pad4_ GND Net-_U4-Pad6_ VCC /PUSH_SW /LED1 /RXD1_DL /LED0 /TXD1_DL /LS_ON /FL_ON /L_CW /L_PULSE VCC NC_01 NC_02 GND /SLEEP /FR_ON /RS_ON /ENC_SS_L /ENC_SS_R /R_PULSE /R_CW VCC /LED2 GND /6500_CS /6500_DI /6500_DO /6500_CLK /BATT_AD /ENC_MISO /ENC_MOSI /ENC_CLK GND /FR_AD VEE /RS_AD /LS_AD GND /FL_AD VEE VEE GND R5F5631MCDFL
U1 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 VCC /6500_DO Net-_C2-Pad1_ GND NC_10 VCC NC_11 NC_12 NC_13 NC_14 GND NC_15 GND NC_16 /6500_CS /6500_CLK /6500_DI MPU-6500
U5 +BATT Net-_P3-Pad2_ Net-_L1-Pad2_ Net-_P4-Pad2_ Net-_L2-Pad2_ GND /R_PULSE /R_CW /L_PULSE /L_CW /SLEEP /SLEEP DRV8836
P1 GND /batt_con BATTERY_CON
SW1 /batt_con Net-_Q8-Pad2_ NC_17 MAIN_SW
R9 GND Net-_Q8-Pad2_ 100k
R17 +BATT Net-_D4-Pad1_ 470
D4 Net-_D4-Pad1_ GND LED
U2 GND +BATT VCC AP7333-28SRG-7
C6 +BATT GND 10u
C9 VCC GND 10u
U3 GND +BATT VEE AP7333-28SRG-7
C7 +BATT GND 10u
C10 VEE GND 10u
X1 Net-_U4-Pad4_ Net-_U4-Pad6_ GND CSTCE12M0G55-R0
C4 VEE GND 0.1u
C5 VCC GND 0.1u
C8 Net-_C8-Pad1_ GND 0.1u
R21 Net-_R21-Pad1_ VCC 10k
P2 /MD /TXD1_DL /RXD1_DL GND DOWNLOAD
R24 /MD VCC 10k
P3 Net-_L1-Pad1_ Net-_P3-Pad2_ L_MOTOR
P4 Net-_L2-Pad1_ Net-_P4-Pad2_ R_MOTOR
L1 Net-_L1-Pad1_ Net-_L1-Pad2_ VLCF5024T-470MR40-2
L2 Net-_L2-Pad1_ Net-_L2-Pad2_ VLCF5024T-470MR40-2
C11 GND +BATT 10u
C3 GND VCC 0.1u
C2 Net-_C2-Pad1_ GND 0.1u
C1 VCC GND 10n
SW2 /PUSH_SW GND PUSH_SW
R22 VCC /PUSH_SW 10k
R19 +BATT /BATT_AD 100k
R20 /BATT_AD GND 100k
Q1 /FR_AD VEE LTR-4206E
R1 /FR_AD GND 1k
R3 Net-_Q2-PadG_ GND 100k
R2 Net-_Q2-PadG_ /FR_ON 1k
Q3 /RS_AD VEE LTR-4206E
R5 /RS_AD GND 1k
Q5 /LS_AD VEE LTR-4206E
R10 /LS_AD GND 1k
Q6 /FL_AD VEE LTR-4206E
R13 /FL_AD GND 1k
Q2 Net-_D1-Pad2_ Net-_Q2-PadG_ GND RUM003N02
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ TSAL4400
R4 Net-_D1-Pad1_ VEE 4.7
R7 Net-_Q4-PadG_ GND 100k
R6 Net-_Q4-PadG_ /RS_ON 1k
Q4 Net-_D2-Pad2_ Net-_Q4-PadG_ GND RUM003N02
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ TSAL4400
R8 Net-_D2-Pad1_ VEE 4.7
R12 Net-_Q7-PadG_ GND 100k
R11 Net-_Q7-PadG_ /LS_ON 1k
Q7 Net-_D3-Pad2_ Net-_Q7-PadG_ GND RUM003N02
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ TSAL4400
R14 Net-_D3-Pad1_ VEE 4.7
R16 Net-_Q9-PadG_ GND 100k
R15 Net-_Q9-PadG_ /FL_ON 1k
Q9 Net-_D5-Pad2_ Net-_Q9-PadG_ GND RUM003N02
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ TSAL4400
R18 Net-_D5-Pad1_ VEE 4.7
U6 Net-_P7-Pad4_ Net-_P7-Pad3_ Net-_P7-Pad2_ Net-_P7-Pad1_ NC_18 NC_19 NC_20 NC_21 Net-_P7-Pad6_ Net-_P7-Pad6_ Net-_P7-Pad5_ Net-_P7-Pad5_ Net-_P7-Pad6_ Net-_P7-Pad5_ NC_22 NC_23 AS5055
P7 Net-_P7-Pad1_ Net-_P7-Pad2_ Net-_P7-Pad3_ Net-_P7-Pad4_ Net-_P7-Pad5_ Net-_P7-Pad6_ L_ENC_SUB
U7 Net-_P8-Pad4_ Net-_P8-Pad3_ Net-_P8-Pad2_ Net-_P8-Pad1_ NC_24 NC_25 NC_26 NC_27 Net-_P8-Pad6_ Net-_P8-Pad6_ Net-_P8-Pad5_ Net-_P8-Pad5_ Net-_P8-Pad6_ Net-_P8-Pad5_ NC_28 NC_29 AS5055
P8 Net-_P8-Pad1_ Net-_P8-Pad2_ Net-_P8-Pad3_ Net-_P8-Pad4_ Net-_P8-Pad5_ Net-_P8-Pad6_ R_ENC_SUB
P5 /ENC_SS_L /ENC_CLK /ENC_MISO /ENC_MOSI VCC GND L_ENC_MAIN
P6 /ENC_SS_R /ENC_CLK /ENC_MISO /ENC_MOSI VCC GND R_ENC_MAIN
C12 GND VCC 10u
C13 GND VCC 10u
R26 /SLEEP GND 10k
D6 /LED0 Net-_D6-Pad2_ LED
R23 GND Net-_D6-Pad2_ 470
D7 /LED1 Net-_D7-Pad2_ LED
R25 GND Net-_D7-Pad2_ 470
D8 /LED2 Net-_D8-Pad2_ LED
R27 GND Net-_D8-Pad2_ 470
Q8 +BATT Net-_Q8-Pad2_ /batt_con ZXM62P02E6
.end
