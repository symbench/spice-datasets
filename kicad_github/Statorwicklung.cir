.title KiCad schematic
U1 Net-_U1-Pad1_ Net-_P1-Pad1_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ Net-_U1-Pad24_ Net-_U1-Pad25_ Net-_U1-Pad26_ Net-_U1-Pad27_ Net-_U1-Pad28_ Net-_U1-Pad29_ Net-_U1-Pad30_ Net-_U1-Pad31_ Net-_U1-Pad32_ Net-_U1-Pad33_ Net-_U1-Pad34_ Net-_U1-Pad35_ Net-_U1-Pad36_ Net-_U1-Pad37_ Net-_U1-Pad38_ Net-_U1-Pad39_ Net-_U1-Pad40_ Net-_U1-Pad41_ Net-_U1-Pad42_ Net-_U1-Pad43_ Net-_U1-Pad44_ Net-_U1-Pad45_ Net-_U1-Pad46_ Net-_U1-Pad47_ Net-_U1-Pad48_ Net-_U1-Pad49_ Net-_U1-Pad50_ Net-_U1-Pad51_ Net-_U1-Pad52_ Net-_U1-Pad53_ Net-_U1-Pad54_ Net-_U1-Pad55_ Net-_U1-Pad56_ Net-_U1-Pad57_ Net-_U1-Pad58_ Net-_U1-Pad59_ Net-_U1-Pad60_ Net-_U1-Pad61_ Net-_U1-Pad62_ Net-_U1-Pad63_ Net-_U1-Pad64_ Mount Mount Mount Mount HARFLEX-64P
U2 Net-_U1-Pad1_ Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U1-Pad6_ Net-_U1-Pad5_ Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_U1-Pad10_ Net-_U1-Pad9_ Net-_U1-Pad12_ Net-_U1-Pad11_ Net-_U1-Pad14_ Net-_U1-Pad13_ Net-_U1-Pad16_ Net-_U1-Pad15_ Net-_U1-Pad18_ Net-_U1-Pad17_ Net-_U1-Pad20_ Net-_U1-Pad19_ Net-_U1-Pad22_ Net-_U1-Pad21_ Net-_U1-Pad24_ Net-_U1-Pad23_ Net-_U1-Pad26_ Net-_U1-Pad25_ Net-_U1-Pad28_ Net-_U1-Pad27_ Net-_U1-Pad30_ Net-_U1-Pad29_ Net-_U1-Pad32_ Net-_U1-Pad31_ Net-_U1-Pad34_ Net-_U1-Pad33_ Net-_U1-Pad36_ Net-_U1-Pad35_ Net-_U1-Pad38_ Net-_U1-Pad37_ Net-_U1-Pad40_ Net-_U1-Pad39_ Net-_U1-Pad42_ Net-_U1-Pad41_ Net-_U1-Pad44_ Net-_U1-Pad43_ Net-_U1-Pad46_ Net-_U1-Pad45_ Net-_U1-Pad48_ Net-_U1-Pad47_ Net-_U1-Pad50_ Net-_U1-Pad49_ Net-_U1-Pad52_ Net-_U1-Pad51_ Net-_U1-Pad54_ Net-_U1-Pad53_ Net-_U1-Pad56_ Net-_U1-Pad55_ Net-_U1-Pad58_ Net-_U1-Pad57_ Net-_U1-Pad60_ Net-_U1-Pad59_ Net-_U1-Pad62_ Net-_U1-Pad61_ Net-_U1-Pad64_ Net-_U1-Pad63_ Net-_P2-Pad1_ Mount Mount Mount Mount HARFLEX-64P
P2 Net-_P2-Pad1_ CONN_01X01
P1 Net-_P1-Pad1_ CONN_01X01
.end
