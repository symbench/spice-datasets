.title KiCad schematic
J6 +3V3 /SWDIO /SWCLK GND SWD
R46 Net-_J5-Pad9_ +3V3 330
C32 /RST GND 104
R50 GND Net-_R50-Pad2_ 10K
U6 /RXD /485RW /485RW /TXD GND /A /B +3V3 MAX485E
C34 /X+ GND 10pF
C35 /X- GND 10pF
R51 GND Net-_R51-Pad2_ 12K
R47 Net-_J5-Pad12_ +3V3 330
C36 GND +3V3 104
R53 GND /B 1K
R54 /A +3V3 1K
J7 /A GND /B 485
C33 Net-_C33-Pad1_ GND 104
U3 GND +1V8 +3V3 AZ1117-1.8
C9 +3V3 GND 104
C10 +1V8 GND 22uF
Y1 /X+ GND /X- GND 30MHz
U4 Net-_R51-Pad2_ +3V3 GND /RXP /RXN +1V8 /TXP /TXN GND /X+ /X- +3V3 GND +3V3 GND +1V8 GND +3V3 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 +1V8 +3V3 NC_07 NC_08 NC_09 NC_10 Net-_C33-Pad1_ GND +3V3 GND +3V3 +1V8 GND +3V3 GND Net-_R52-Pad1_ Net-_J5-Pad10_ +1V8 NC_11 GND /SPI_CS /SPI_SCK /SPI_MOSI /SPI_MISO +3V3 +1V8 CH395Q
C13 GND +3V3 104
C26 +1V8 GND 104
R44 /RXN +3V3 49.9
R45 /RXP +3V3 49.9
R48 /TXN +3V3 49.9
R49 /TXP +3V3 49.9
C12 +3V3 GND 104
C11 +3V3 GND 2.2uF
C28 +1V8 GND 104
C29 +1V8 GND 104
C30 +1V8 GND 104
C14 +3V3 GND 104
C15 +3V3 GND 104
C16 +3V3 GND 104
C17 +3V3 GND 104
C18 +3V3 GND 104
C19 +3V3 GND 104
C20 +3V3 GND 104
C21 +3V3 GND 104
C31 +1V8 GND 104
U5 +3V3 NC_12 NC_13 NC_14 NC_15 NC_16 /RST GND +3V3 NC_17 Net-_R52-Pad2_ /TXD /RXD /SPI_CS /SPI_SCK /SPI_MISO /SPI_MOSI NC_18 NC_19 NC_20 NC_21 /485RW GND +3V3 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 /SWDIO NC_31 NC_32 /SWCLK NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 Net-_R50-Pad2_ NC_39 NC_40 GND +3V3 STM32F030C8Tx
C22 +3V3 GND 104
C23 +3V3 GND 104
C24 +3V3 GND 104
C25 +3V3 GND 104
R52 Net-_R52-Pad1_ Net-_R52-Pad2_ 100
J2 /RST Conn_01x01
J5 /TXP /TXN /RXP +3V3 +3V3 /RXN GND Net-_J5-Pad9_ Net-_J5-Pad10_ Net-_J5-Pad10_ Net-_J5-Pad12_ HR913550A
.end
