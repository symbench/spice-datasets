.title KiCad schematic
UK8 LBR* /A_0_ /A_30_ /A_28_ /A_26_ /A_24_ /A_23_ /A_21_ /A_19_ /A_17_ /A_15_ /A_13_ /A_10_ RMC* /LBG* /A_31_ /A_29_ /A_27_ /A_25_ /A_22_ /A_20_ /A_16_ /A_14_ /A_12_ /A_8_ /A_7_ /FC_1_ /CIOUT* LBGACK* /A_1_ /A_18_ /A_11_ /A_9_ /A_5_ /A_4_ /FC_2_ /FC_0_ NC_01 /A_6_ /A_3_ /A_2_ C16M NC_02 NC_03 NC_04 RESET* NC_05 STERM* NC_06 NC_07 NC_08 BERR* HALT* NC_09 NC_10 CBACK* LAS* NC_11 NC_12 NC_13 DS* /SIZ_1_ /D_5_ /D_1_ /D_0_ NC_14 /SIZ_0_ R-W* /D_30_ /D_10_ /D_7_ /D_4_ /D_2_ NC_15 NC_16 /D_29_ /D_27_ /D_24_ /D_22_ /D_20_ /D_17_ /D_14_ /D_12_ /D_9_ /D_6_ /D_3_ /D_31_ /D_28_ /D_26_ /D_25_ /D_23_ /D_21_ /D_19_ /D_18_ /D_16_ /D_15_ /D_13_ /D_11_ /D_8_ 68030
UI6 NC_17 NC_18 LAS* NC_19 NC_20 /FC_2_ /FC_1_ /FC_0_ LBGACK* NC_21 BERR* IRQ*_1:6_ NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 PAL16R4B
J13 NC_28 NC_29 NC_30 IRQ*_1:6_ NC_31 /CIOUT* STERM* /DSACK*_1_ /SIZ_1_ LBGACK* /FC_2_ RESET* /D_0_ /D_2_ /D_5_ /D_8_ /D_10_ /D_13_ /D_16_ /D_18_ /D_21_ /D_24_ /D_26_ /D_29_ /A_31_ /A_29_ /A_26_ /A_23_ /A_21_ /A_18_ /A_15_ /A_13_ /A_10_ /A_7_ /A_5_ /A_2_ NC_32 C16M NC_33 NC_34 NC_35 Net-_J13-Pad42_ NC_36 IRQ*_1:6_ NC_37 DS* CBACK* /DSACK*_0_ /SIZ_0_ /LBG* /FC_1_ BERR* Net-_J13-Pad53_ /D_3_ /D_6_ Net-_J13-Pad42_ /D_11_ /D_14_ Net-_J13-Pad53_ /D_19_ /D_22_ Net-_J13-Pad42_ /D_27_ /D_30_ Net-_J13-Pad53_ /A_28_ /A_25_ Net-_J13-Pad42_ /A_20_ /A_17_ Net-_J13-Pad53_ /A_12_ /A_9_ Net-_J13-Pad42_ /A_4_ /A_1_ Net-_J13-Pad53_ NC_38 Net-_J13-Pad42_ NC_39 NC_40 NC_41 NC_42 IRQ*_1:6_ NC_43 RMC* NC_44 R-W* LAS* LBR* /FC_0_ HALT* /D_1_ /D_4_ /D_7_ /D_9_ /D_12_ /D_15_ /D_17_ /D_20_ /D_23_ /D_25_ /D_28_ /D_31_ /A_30_ /A_27_ /A_24_ /A_22_ /A_19_ /A_16_ /A_14_ /A_11_ /A_8_ /A_6_ /A_3_ /A_0_ NC_45 C16M NC_46 NC_47 PDS_03x80
UI5 /D_2_ /D_1_ /D_0_ NC_48 C16M RESET* Net-_UI5-Pad18_ DS* LAS* /A_4_ /A_3_ /A_2_ /A_1_ Net-_UI5-Pad18_ R-W* NC_49 /DSACK*_0_ /DSACK*_1_ /D_31_ /D_30_ /D_29_ /D_28_ /D_27_ /D_26_ /D_25_ /D_24_ /D_23_ /D_22_ /D_21_ /D_20_ /D_19_ /D_18_ /D_17_ /D_16_ /D_15_ /D_14_ /D_13_ /D_12_ /D_11_ /D_10_ /D_9_ /D_8_ /D_7_ /D_6_ /D_5_ /D_4_ /D_3_ MC68882RC16
.end
