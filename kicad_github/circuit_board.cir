.title KiCad schematic
R1 Net-_Q1-Pad2_ in_1 220K
C3 +12V GND 100nF
C4 -12V GND 100nF
C1 +12V GND 10uF
D2 Net-_D2-Pad1_ -12V 1N4148
D1 +12V Net-_D1-Pad2_ 1N4148
J5 Net-_D2-Pad1_ Net-_D2-Pad1_ GND GND GND GND GND GND Net-_D1-Pad2_ Net-_D1-Pad2_ Conn_01x10
C2 GND -12V 10uF
R3 Net-_R3-Pad1_ cv_1 100K
R5 GND Net-_Q1-Pad2_ 1K
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_Q1-Pad3_ 2N3904
Q3 Net-_Q1-Pad1_ Net-_Q3-Pad2_ Net-_Q3-Pad3_ 2N3904
R8 Net-_Q1-Pad3_ Net-_R8-Pad2_ 20K
R12 Net-_Q3-Pad3_ Net-_R12-Pad2_ 20K
RV3 Net-_R8-Pad2_ +12V Net-_R12-Pad2_ 1K
R9 Net-_Q2-Pad1_ Net-_Q1-Pad1_ 20K
R10 -12V Net-_Q2-Pad1_ 10K
Q2 Net-_Q2-Pad1_ Net-_Q2-Pad2_ GND 2N3904
R6 Net-_Q2-Pad2_ Net-_R4-Pad1_ 10K
R7 Net-_Q2-Pad2_ Net-_R7-Pad2_ 10K
RV2 +12V Net-_R7-Pad2_ GND 10K
R4 Net-_R4-Pad1_ Net-_R3-Pad1_ 100K
R14 Net-_R14-Pad1_ Net-_Q3-Pad3_ 20K
R13 GND Net-_Q3-Pad2_ 1K
R15 Net-_R15-Pad1_ Net-_Q1-Pad3_ 20K
R16 Net-_R14-Pad1_ GND 220K
R17 out_1 Net-_R15-Pad1_ 220K
R19 Net-_Q4-Pad2_ in_2 220K
R2 Net-_R18-Pad2_ cv_2 100K
R20 GND Net-_Q4-Pad2_ 1K
Q4 Net-_Q4-Pad1_ Net-_Q4-Pad2_ Net-_Q4-Pad3_ 2N3904
Q6 Net-_Q4-Pad1_ Net-_Q6-Pad2_ Net-_Q6-Pad3_ 2N3904
R23 Net-_Q4-Pad3_ Net-_R23-Pad2_ 20K
R26 Net-_Q6-Pad3_ Net-_R26-Pad2_ 20K
RV6 Net-_R23-Pad2_ +12V Net-_R26-Pad2_ 1K
R24 Net-_Q5-Pad1_ Net-_Q4-Pad1_ 20K
R25 -12V Net-_Q5-Pad1_ 10K
Q5 Net-_Q5-Pad1_ Net-_Q5-Pad2_ GND 2N3904
R21 Net-_Q5-Pad2_ Net-_R18-Pad1_ 10K
R22 Net-_Q5-Pad2_ Net-_R22-Pad2_ 10K
RV5 +12V Net-_R22-Pad2_ GND 10K
R18 Net-_R18-Pad1_ Net-_R18-Pad2_ 100K
R28 Net-_R28-Pad1_ Net-_Q6-Pad3_ 20K
R27 GND Net-_Q6-Pad2_ 1K
R29 Net-_R29-Pad1_ Net-_Q4-Pad3_ 20K
R30 Net-_R28-Pad1_ GND 220K
R31 out_2 Net-_R29-Pad1_ 220K
U1 Net-_R4-Pad1_ Net-_R3-Pad1_ GND +12V Net-_R28-Pad1_ Net-_R29-Pad1_ out_2 Net-_R18-Pad1_ Net-_R18-Pad2_ GND -12V Net-_R14-Pad1_ Net-_R15-Pad1_ out_1 TL074
J9 in_1 cv_1 in_2 cv_2 out_1 out_2 GND back board connector
.end
