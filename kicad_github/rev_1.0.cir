.title KiCad schematic
C2 GND Net-_C2-Pad2_ 0.1uF
C1 +5V GND 1uF
C3 +5V GND 1uF
C6 +5V GND 1uF
RP8 Net-_PLED_5V1-Pad2_ +5V 1k
PLED_5V1 GND Net-_PLED_5V1-Pad2_ Green
ICSP1 /MISO +5V /SCK /MOSI /RESET GND ICSP
Y1 /XTAL1 /XTAL2 16MHz
C5 GND /XTAL2 20pF
C4 GND /XTAL1 20pF
MCU0 /MOSI /MISO /SCK /RESET +5V GND /XTAL2 /XTAL1 /RX0 /TX0 /RX1 /TX1 /PCINT28 /PCINT29 /PCINT30 /PCINT31 +5V GND /SCL /SDA /PCINT18 /PCINT19 /PCINT20 /PCINT21 /PCINT22 /PCINT23 +5V GND Net-_C2-Pad2_ NC_01 NC_02 NC_03 NC_04 /A3 /A2 /A1 /A0 +5V GND /PCINT8 /PCINT9 /PCINT10 /PCINT11 NC_05 ATmega1284-AU
U6 Net-_C17-Pad2_ Net-_C18-Pad1_ Net-_BT1-Pad1_ GND /SDA /SCL NC_06 +5V MCP7940N-xSN
C16 +5V GND 1uF
Y2 Net-_C17-Pad2_ Net-_C18-Pad1_ 32.768 kHz
C18 Net-_C18-Pad1_ GND 18pF
C17 GND Net-_C17-Pad2_ 18pF
RP3 +5V /SCL 4.7k
RP4 +5V /SDA 4.7k
U2 GND +3V3 +7.5V LM1117-3.3
C7 +3V3 GND 1uF
RP2 Net-_PLED_3V3-Pad2_ +3V3 1k
PLED_3V3 GND Net-_PLED_3V3-Pad2_ Green
C8 +5V GND 4.7uF_16V
BT1 Net-_BT1-Pad1_ GND 3V Coin Cell
U5 +3V3 /MOSI_3V3 /MISO_3V3 /SCK_3V3 /CS_3V3 NC_07 GND Net-_RP7-Pad2_ NC_08 /PCINT28 /SCK /MISO /MOSI +5V TXB0104D
C13 +3V3 GND 0.1uF
C14 GND +5V 0.1uF
C11 GND +5V 0.1uF
C9 +3V3 GND 0.1uF
U3 +3V3 /TX_3V3 /RX_3V3 /P2_0 /P0_0 NC_09 GND Net-_RP5-Pad2_ NC_10 /PCINT19 /PCINT18 /TX1 /RX1 +5V TXB0104D
RP5 +3V3 Net-_RP5-Pad2_ 1k
RP7 +3V3 Net-_RP7-Pad2_ 1k
POWER1 +7.5V GND Vsupply
R1 /XTAL1 /XTAL2 1M
J2 +7.5V GND Net-_J2-Pad3_ RF_BHE
J10 /A3 +5V GND RR_rh
J8 /A2 +5V GND LR_rh
J7 /A0 +5V GND LF_rh
J9 /A1 +5V GND RF_rh
C15 +3V3 GND 1uF
J13 NC_11 /CS_3V3 /MOSI_3V3 +3V3 /SCK_3V3 GND /MISO_3V3 NC_12 NC_13 NC_14 GND Micro_SD_Card_Det_Hirose_DM3AT
RP1 +5V /RESET 10k
SW1 GND /RESET BT_RST
J6 /SDA /SCL +5V GND CVT_IR
J11 /PCINT8 +5V GND Tach
CAN1 GND NC_15 /MOSI /MISO /SCK /PCINT30 /RESET NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 +5V GND SPI_CAN_BREAKOUT
J12 +5V GND NC_23 /SCK /MISO /MOSI /PCINT29 NC_24 MAX31865
J14 NC_25 Net-_J14-Pad2_ NC_26 NC_27 /RX0 /TX0 GND +5V NC_28 Ulti_GPS_v3
RP9 Net-_J14-Pad2_ +5V 10k
C12 GND +5V 0.1uF
C10 +3V3 GND 0.1uF
U4 +3V3 /BT_RST /P3_6 /P1_6 /P1_7 NC_29 GND Net-_RP6-Pad2_ NC_30 /PCINT23 /PCINT22 /PCINT21 /PCINT20 +5V TXB0104D
RP6 +3V3 Net-_RP6-Pad2_ 1k
R4 Net-_J2-Pad3_ /PCINT9 1k
R2 GND /PCINT9 4.7k
R6 GND /PCINT10 4.7k
R7 Net-_J5-Pad3_ /PCINT10 1k
J3 +7.5V GND Net-_J3-Pad3_ Output_BHE
R3 GND /PCINT11 4.7k
R5 Net-_J3-Pad3_ /PCINT11 1k
J4 +5V GND /SDA /SCL /PCINT31 IMU_bout
U1 GND +5V +7.5V LM1117-5.0
J5 +7.5V GND Net-_J5-Pad3_ LF_BHE
C19 +3V3 GND 10uF
SW2 GND /BlueTooth/RST_BT BT_RST
RP12 +3V3 /BlueTooth/RST_BT 10k
D2 /BlueTooth/P2_7 Net-_D2-Pad2_ BT_TX_LED
RP11 Net-_D2-Pad2_ +3V3 1k
RP10 Net-_D1-Pad2_ +3V3 1k
D1 /BlueTooth/P0_2 Net-_D1-Pad2_ BT_PLED
U7 NC_31 GND NC_32 NC_33 /P1_7 /P1_6 /RX_3V3 /TX_3V3 /P3_6 /BT_RST /P0_0 /BlueTooth/P0_2 GND +3V3 /BlueTooth/P2_7 /P2_0 RN4871-V/RM118
.end
