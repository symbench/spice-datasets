.title KiCad schematic
U8 Net-_U8-Pad1_ NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 /SDI /CS /SCLK NC_12 NC_13 NC_14 SubL NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 SubR NC_21 Net-_U8-Pad1_ PGA4311
U6 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NE5532
P1 Net-_P1-Pad1_ Net-_P1-Pad1_ NC_30 NC_31 A-POWER
U2 Net-_P1-Pad1_ NC_32 Net-_U2-Pad3_ 79M15
U1 NC_33 Net-_P1-Pad1_ Net-_U1-Pad3_ 78M15
D4 Net-_D4-Pad1_ NC_34 LED
D3 Net-_D3-Pad1_ NC_35 LED
D9 Net-_D9-Pad1_ NC_36 LED
P8 Net-_P8-Pad1_ Net-_P8-Pad1_ NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 Net-_P8-Pad10_ Net-_P8-Pad10_ CTRL_RELAYS
U7 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NE5532
P2 NC_51 NC_52 RSA-IN1L
P4 NC_53 NC_54 RSA-IN1R
P5 NC_55 NC_56 RSA-INTR
P3 NC_57 NC_58 RSA-INTL
P13 NC_59 NC_60 /CS /SCLK /SDI NC_61 NC_62 NC_63 CTRL_VOLUME
K4 NC_64 /IN-L /IN13-L NC_65 NC_66 /IN13-R /IN-R Net-_D9-Pad1_ G6K-2F
K1 NC_67 NC_68 NC_69 /IN13-L /IN13-R NC_70 NC_71 Net-_D3-Pad1_ G6K-2F
K2 NC_72 NC_73 NC_74 /IN-L /IN-R NC_75 NC_76 Net-_D4-Pad1_ G6K-2F
U3 NC_77 NC_78 Net-_U1-Pad3_ 78L05
U4 NC_79 Net-_P1-Pad1_ Net-_U1-Pad3_ 78L05
U5 Net-_P1-Pad1_ Net-_U2-Pad3_ NC_80 79L05
D12 Net-_D12-Pad1_ NC_81 LED
P14 NC_82 NC_83 RSA-IN2L
P15 NC_84 NC_85 RSA-IN2R
K3 NC_86 NC_87 NC_88 /IN13-L /IN13-R NC_89 NC_90 Net-_D12-Pad1_ G6K-2F
D14 Net-_D14-Pad1_ NC_91 LED
P16 NC_92 NC_93 RSA-IN3L
P17 NC_94 NC_95 RSA-IN3R
K5 NC_96 NC_97 NC_98 /IN13-L /IN13-R NC_99 NC_100 Net-_D14-Pad1_ G6K-2F
U9 SubL SubL NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 SubR SubR TL074
J1 NC_111 NC_112 CONN_01X02
J6 NC_113 NC_114 CONN_01X02
J2 NC_115 NC_116 CONN_01X02
J3 NC_117 NC_118 CONN_01X02
J4 NC_119 NC_120 CONN_01X02
J5 NC_121 NC_122 CONN_01X02
.end
