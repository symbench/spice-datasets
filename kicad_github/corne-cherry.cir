.title KiCad schematic
U1 NC_01 data Net-_U1-Pad3_ Net-_U1-Pad3_ NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 col5 col4 col3 col2 col1 col0 NC_12 reset NC_13 NC_14 ProMicro
SW2 col1 NC_15 SW_PUSH
SW3 col2 NC_16 SW_PUSH
SW4 col3 NC_17 SW_PUSH
SW5 col4 NC_18 SW_PUSH
SW6 col5 NC_19 SW_PUSH
SW1 col0 NC_20 SW_PUSH
SW8 col1 NC_21 SW_PUSH
SW9 col2 NC_22 SW_PUSH
SW10 col3 NC_23 SW_PUSH
SW11 col4 NC_24 SW_PUSH
SW12 col5 NC_25 SW_PUSH
SW7 col0 NC_26 SW_PUSH
SW14 col1 NC_27 SW_PUSH
SW15 col2 NC_28 SW_PUSH
SW16 col3 NC_29 SW_PUSH
SW17 col4 NC_30 SW_PUSH
SW18 col5 NC_31 SW_PUSH
SW13 col0 NC_32 SW_PUSH
SW20 col4 NC_33 SW_PUSH
SW21 col5 NC_34 SW_PUSH
SW19 col3 NC_35 SW_PUSH
RSW1 reset NC_36 SW_PUSH
J1 NC_37 data NC_38 NC_39 MJ-4PP-9
U2 NC_40 data_r Net-_U2-Pad3_ Net-_U2-Pad3_ NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 col5_r col4_r col3_r col2_r col1_r col0_r NC_51 reset_r NC_52 NC_53 ProMicro
SW23 col1_r NC_54 SW_PUSH
SW24 col2_r NC_55 SW_PUSH
SW25 col3_r NC_56 SW_PUSH
SW26 col4_r NC_57 SW_PUSH
SW27 col5_r NC_58 SW_PUSH
SW22 col0_r NC_59 SW_PUSH
SW29 col1_r NC_60 SW_PUSH
SW30 col2_r NC_61 SW_PUSH
SW31 col3_r NC_62 SW_PUSH
SW32 col4_r NC_63 SW_PUSH
SW33 col5_r NC_64 SW_PUSH
SW28 col0_r NC_65 SW_PUSH
SW35 col1_r NC_66 SW_PUSH
SW36 col2_r NC_67 SW_PUSH
SW37 col3_r NC_68 SW_PUSH
SW38 col4_r NC_69 SW_PUSH
SW39 col5_r NC_70 SW_PUSH
SW34 col0_r NC_71 SW_PUSH
SW41 col4_r NC_72 SW_PUSH
SW42 col5_r NC_73 SW_PUSH
SW40 col3_r NC_74 SW_PUSH
RSW2 reset_r NC_75 SW_PUSH
J3 NC_76 data_r NC_77 NC_78 MJ-4PP-9
LED7 Net-_LED10-Pad1_ Net-_LED13-Pad4_ Net-_LED10-Pad3_ Net-_LED7-Pad4_ YS-SK6812MINI-E
LED8 Net-_LED10-Pad1_ Net-_LED7-Pad4_ Net-_LED10-Pad3_ Net-_LED14-Pad2_ YS-SK6812MINI-E
LED9 Net-_LED10-Pad1_ Net-_LED15-Pad4_ Net-_LED10-Pad3_ Net-_LED10-Pad2_ YS-SK6812MINI-E
LED10 Net-_LED10-Pad1_ Net-_LED10-Pad2_ Net-_LED10-Pad3_ Net-_LED10-Pad4_ YS-SK6812MINI-E
LED11 Net-_LED10-Pad1_ Net-_LED11-Pad2_ Net-_LED10-Pad3_ Net-_LED11-Pad4_ YS-SK6812MINI-E
LED12 Net-_LED10-Pad1_ Net-_LED11-Pad4_ Net-_LED10-Pad3_ Net-_LED12-Pad4_ YS-SK6812MINI-E
LED13 Net-_LED10-Pad1_ Net-_LED13-Pad2_ Net-_LED10-Pad3_ Net-_LED13-Pad4_ YS-SK6812MINI-E
LED14 Net-_LED10-Pad1_ Net-_LED14-Pad2_ Net-_LED10-Pad3_ Net-_LED14-Pad4_ YS-SK6812MINI-E
LED15 Net-_LED10-Pad1_ Net-_LED15-Pad2_ Net-_LED10-Pad3_ Net-_LED15-Pad4_ YS-SK6812MINI-E
LED16 Net-_LED10-Pad1_ Net-_LED10-Pad4_ Net-_LED10-Pad3_ Net-_LED16-Pad4_ YS-SK6812MINI-E
LED17 Net-_LED10-Pad1_ Net-_LED17-Pad2_ Net-_LED10-Pad3_ Net-_LED11-Pad2_ YS-SK6812MINI-E
LED18 Net-_LED10-Pad1_ Net-_LED12-Pad4_ Net-_LED10-Pad3_ Net-_LED18-Pad4_ YS-SK6812MINI-E
LED19 Net-_LED10-Pad1_ NC_79 Net-_LED10-Pad3_ Net-_LED13-Pad2_ YS-SK6812MINI-E
LED20 Net-_LED10-Pad1_ Net-_LED14-Pad4_ Net-_LED10-Pad3_ Net-_LED20-Pad4_ YS-SK6812MINI-E
LED21 Net-_LED10-Pad1_ Net-_LED20-Pad4_ Net-_LED10-Pad3_ Net-_LED15-Pad2_ YS-SK6812MINI-E
LED22 Net-_LED10-Pad1_ Net-_LED16-Pad4_ Net-_LED10-Pad3_ Net-_LED22-Pad4_ YS-SK6812MINI-E
LED23 Net-_LED10-Pad1_ Net-_LED23-Pad2_ Net-_LED10-Pad3_ Net-_LED17-Pad2_ YS-SK6812MINI-E
LED24 Net-_LED10-Pad1_ Net-_LED18-Pad4_ Net-_LED10-Pad3_ Net-_LED24-Pad4_ YS-SK6812MINI-E
LED25 Net-_LED10-Pad1_ Net-_LED22-Pad4_ Net-_LED10-Pad3_ Net-_LED25-Pad4_ YS-SK6812MINI-E
LED26 Net-_LED10-Pad1_ Net-_LED25-Pad4_ Net-_LED10-Pad3_ Net-_LED23-Pad2_ YS-SK6812MINI-E
LED27 Net-_LED10-Pad1_ Net-_LED24-Pad4_ Net-_LED10-Pad3_ NC_80 YS-SK6812MINI-E
LED34 Net-_LED34-Pad1_ Net-_LED34-Pad2_ Net-_LED34-Pad3_ Net-_LED34-Pad4_ YS-SK6812MINI-E
LED35 Net-_LED34-Pad1_ Net-_LED34-Pad4_ Net-_LED34-Pad3_ Net-_LED35-Pad4_ YS-SK6812MINI-E
LED36 Net-_LED34-Pad1_ Net-_LED36-Pad2_ Net-_LED34-Pad3_ Net-_LED36-Pad4_ YS-SK6812MINI-E
LED37 Net-_LED34-Pad1_ Net-_LED36-Pad4_ Net-_LED34-Pad3_ Net-_LED37-Pad4_ YS-SK6812MINI-E
LED38 Net-_LED34-Pad1_ Net-_LED38-Pad2_ Net-_LED34-Pad3_ Net-_LED38-Pad4_ YS-SK6812MINI-E
LED39 Net-_LED34-Pad1_ Net-_LED38-Pad4_ Net-_LED34-Pad3_ Net-_LED39-Pad4_ YS-SK6812MINI-E
LED40 Net-_LED34-Pad1_ Net-_LED40-Pad2_ Net-_LED34-Pad3_ Net-_LED34-Pad2_ YS-SK6812MINI-E
LED41 Net-_LED34-Pad1_ Net-_LED35-Pad4_ Net-_LED34-Pad3_ Net-_LED41-Pad4_ YS-SK6812MINI-E
LED42 Net-_LED34-Pad1_ Net-_LED42-Pad2_ Net-_LED34-Pad3_ Net-_LED36-Pad2_ YS-SK6812MINI-E
LED43 Net-_LED34-Pad1_ Net-_LED37-Pad4_ Net-_LED34-Pad3_ Net-_LED43-Pad4_ YS-SK6812MINI-E
LED44 Net-_LED34-Pad1_ Net-_LED44-Pad2_ Net-_LED34-Pad3_ Net-_LED38-Pad2_ YS-SK6812MINI-E
LED45 Net-_LED34-Pad1_ Net-_LED39-Pad4_ Net-_LED34-Pad3_ Net-_LED45-Pad4_ YS-SK6812MINI-E
LED46 Net-_LED34-Pad1_ NC_81 Net-_LED34-Pad3_ Net-_LED40-Pad2_ YS-SK6812MINI-E
LED47 Net-_LED34-Pad1_ Net-_LED41-Pad4_ Net-_LED34-Pad3_ Net-_LED47-Pad4_ YS-SK6812MINI-E
LED48 Net-_LED34-Pad1_ Net-_LED47-Pad4_ Net-_LED34-Pad3_ Net-_LED42-Pad2_ YS-SK6812MINI-E
LED49 Net-_LED34-Pad1_ Net-_LED43-Pad4_ Net-_LED34-Pad3_ Net-_LED49-Pad4_ YS-SK6812MINI-E
LED50 Net-_LED34-Pad1_ Net-_LED50-Pad2_ Net-_LED34-Pad3_ Net-_LED44-Pad2_ YS-SK6812MINI-E
LED51 Net-_LED34-Pad1_ Net-_LED45-Pad4_ Net-_LED34-Pad3_ Net-_LED51-Pad4_ YS-SK6812MINI-E
LED52 Net-_LED34-Pad1_ Net-_LED49-Pad4_ Net-_LED34-Pad3_ Net-_LED52-Pad4_ YS-SK6812MINI-E
LED53 Net-_LED34-Pad1_ Net-_LED52-Pad4_ Net-_LED34-Pad3_ Net-_LED50-Pad2_ YS-SK6812MINI-E
LED54 Net-_LED34-Pad1_ Net-_LED51-Pad4_ Net-_LED34-Pad3_ NC_82 YS-SK6812MINI-E
.end
