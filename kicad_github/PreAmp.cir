.title KiCad schematic
U8 Net-_R31-Pad1_ GNDA InBuffR GNDA Net-_R32-Pad2_ -5V +5V Net-_R34-Pad2_ GNDA InBuffL GNDA +5VD /SDI /CS /SCLK NC_01 GNDPWR GNDA SubL GNDA Net-_R35-Pad2_ +5V -5V Net-_R33-Pad2_ GNDA SubR GNDA Net-_R31-Pad1_ PGA4311
U6 Net-_R24-Pad1_ Net-_R18-Pad1_ GNDA -15V GNDA Net-_R17-Pad1_ Net-_R23-Pad1_ +15V NE5532
P1 GNDPWR GNDPWR Net-_D1-Pad2_ Net-_D2-Pad1_ A-POWER
C19 +15V GNDPWR 100n
C21 +15V GNDPWR 100n
C9 Net-_C9-Pad1_ /IN-L 1u
R13 Net-_C9-Pad1_ GNDA 100k
R17 Net-_R17-Pad1_ Net-_C9-Pad1_ 47k
R23 Net-_R23-Pad1_ Net-_R17-Pad1_ 47k
R27 InBuffL Net-_R23-Pad1_ 100
C10 Net-_C10-Pad1_ /IN-R 1u
R14 Net-_C10-Pad1_ GNDA 100k
R18 Net-_R18-Pad1_ Net-_C10-Pad1_ 47k
R24 Net-_R24-Pad1_ Net-_R18-Pad1_ 47k
R28 InBuffR Net-_R24-Pad1_ 100
D8 VDD Net-_D4-Pad1_ 1N4148
C20 GNDPWR -15V 100n
C22 GNDPWR -15V 100n
U2 GNDPWR Net-_C2-Pad2_ -15V 79M15
U1 Net-_C1-Pad1_ GNDPWR +15V 78M15
C1 Net-_C1-Pad1_ GNDPWR 47u
C2 GNDPWR Net-_C2-Pad2_ 47u
C3 Net-_C1-Pad1_ GNDPWR 100n
C4 GNDPWR Net-_C2-Pad2_ 100n
D6 Net-_D2-Pad2_ Net-_C2-Pad2_ D
D5 Net-_C1-Pad1_ Net-_D1-Pad1_ D
D1 Net-_D1-Pad1_ Net-_D1-Pad2_ D
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ D
C5 +15V GNDPWR 47u
C6 GNDPWR -15V 47u
C7 +15V GNDPWR 100n
C8 GNDPWR -15V 100n
C14 +5V GNDPWR 47u
C15 GNDPWR -5V 47u
C17 +5V GNDPWR 100n
C18 GNDPWR -5V 100n
R8 Net-_Q2-Pad1_ /SELECT-INT 1k
R5 Net-_K2-Pad3_ /INTL X
R11 Net-_K2-Pad3_ GNDA 47k
R6 Net-_K2-Pad6_ /INTR X
R12 Net-_K2-Pad6_ GNDA 47k
C25 VDD GND 47u
C26 VDD GND 100n
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R2 Net-_D4-Pad2_ VDD 10k
D7 VDD Net-_D3-Pad1_ 1N4148
R7 Net-_Q1-Pad1_ /SELECT-IN1 1k
R3 Net-_K1-Pad3_ /IN1L X
R9 Net-_K1-Pad3_ GNDA 47k
R4 Net-_K1-Pad6_ /IN1R X
R10 Net-_K1-Pad6_ GNDA 47k
D3 Net-_D3-Pad1_ Net-_D3-Pad2_ LED
R1 Net-_D3-Pad2_ VDD 10k
D10 VDD Net-_D10-Pad2_ 1N4148
R22 Net-_Q3-Pad1_ /SELECT-TL 1k
D9 Net-_D10-Pad2_ Net-_D9-Pad2_ LED
R21 Net-_D9-Pad2_ VDD 10k
P8 GND GND /SELECT-TL /SELECT-IN3 /SELECT-INT /SELECT-IN2 NC_02 /SELECT-IN1 VDD VDD CTRL_RELAYS
C33 +5V GNDA 100n
C34 GNDA -5V 100n
U7 Net-_R25-Pad1_ Net-_R19-Pad1_ GNDA -15V GNDA Net-_R20-Pad1_ Net-_R26-Pad1_ +15V NE5532
C11 Net-_C11-Pad1_ /OUT-T-L 1u
R15 Net-_C11-Pad1_ GNDA 100k
R19 Net-_R19-Pad1_ Net-_C11-Pad1_ 47k
R25 Net-_R25-Pad1_ Net-_R19-Pad1_ 47k
R29 /OUT-TB-L Net-_R25-Pad1_ 100
C12 Net-_C12-Pad1_ /OUT-T-R 1u
R16 Net-_C12-Pad1_ GNDA 100k
R20 Net-_R20-Pad1_ Net-_C12-Pad1_ 47k
R26 Net-_R26-Pad1_ Net-_R20-Pad1_ 47k
R30 /OUT-TB-R Net-_R26-Pad1_ 100
P2 /IN1L GNDA RSA-IN1L
P4 /IN1R GNDA RSA-IN1R
P5 /INTR GNDA RSA-INTR
P3 /INTL GNDA RSA-INTL
C13 +5VD GNDPWR 47u
C16 +5VD GNDPWR 100n
C36 +5VD GNDPWR 1u
C37 +5VD GNDPWR 100n
C35 -5V GNDPWR 100n
R31 Net-_R31-Pad1_ +5VD 1k
R32 OUT-R Net-_R32-Pad2_ 100
R33 /OUT-SR Net-_R33-Pad2_ 100
R36 Net-_C27-Pad2_ OUT-L 15k4
C27 GNDA Net-_C27-Pad2_ 100n
R40 Net-_R40-Pad1_ Net-_R38-Pad2_ 47k
R38 GNDA Net-_R38-Pad2_ 2k2
R42 Net-_C29-Pad1_ Net-_R40-Pad1_ 4k87
R44 Net-_C31-Pad2_ Net-_C29-Pad1_ 11k
C31 GNDA Net-_C31-Pad2_ 100n
C29 Net-_C29-Pad1_ SubL 470n
R37 Net-_C28-Pad2_ OUT-R 15k4
C28 GNDA Net-_C28-Pad2_ 100n
R41 Net-_R41-Pad1_ Net-_R39-Pad2_ 47k
R39 GNDA Net-_R39-Pad2_ 2k2
R43 Net-_C30-Pad1_ Net-_R41-Pad1_ 4k87
R45 Net-_C32-Pad2_ Net-_C30-Pad1_ 11k
C32 GNDA Net-_C32-Pad2_ 100n
C30 Net-_C30-Pad1_ SubR 470n
R34 OUT-L Net-_R34-Pad2_ 100
R35 /OUT-SL Net-_R35-Pad2_ 100
Q1 Net-_Q1-Pad1_ GND Net-_D3-Pad1_ BC817
Q2 Net-_Q2-Pad1_ GND Net-_D4-Pad1_ BC817
Q3 Net-_Q3-Pad1_ GND Net-_D10-Pad2_ BC817
P13 GNDPWR GNDPWR /CS /SCLK /SDI NC_03 +5VD +5VD CTRL_VOLUME
K4 VDD /IN-L /IN13-L /OUT-T-L /OUT-T-R /IN13-R /IN-R Net-_D10-Pad2_ G6K-2F
K1 VDD NC_04 Net-_K1-Pad3_ /IN13-L /IN13-R Net-_K1-Pad6_ NC_05 Net-_D3-Pad1_ G6K-2F
K2 VDD NC_06 Net-_K2-Pad3_ /IN-L /IN-R Net-_K2-Pad6_ NC_07 Net-_D4-Pad1_ G6K-2F
U3 +5VD GNDPWR +15V 78L05
U4 +5V GNDPWR +15V 78L05
U5 GNDPWR -15V -5V 79L05
C38 +15V GNDPWR 100n
C39 GNDPWR -15V 100n
D11 VDD Net-_D11-Pad2_ 1N4148
R51 Net-_Q4-Pad1_ /SELECT-IN2 1k
R47 Net-_K3-Pad3_ /IN2L X
R46 Net-_K3-Pad3_ GNDA 47k
R49 Net-_K3-Pad6_ /IN2R X
R48 Net-_K3-Pad6_ GNDA 47k
D12 Net-_D11-Pad2_ Net-_D12-Pad2_ LED
R50 Net-_D12-Pad2_ VDD 10k
P14 /IN2L GNDA RSA-IN2L
P15 /IN2R GNDA RSA-IN2R
Q4 Net-_Q4-Pad1_ GND Net-_D11-Pad2_ BC817
K3 VDD NC_08 Net-_K3-Pad3_ /IN13-L /IN13-R Net-_K3-Pad6_ NC_09 Net-_D11-Pad2_ G6K-2F
D13 VDD Net-_D13-Pad2_ 1N4148
R57 Net-_Q5-Pad1_ /SELECT-IN3 1k
R53 Net-_K5-Pad3_ /IN3L X
R52 Net-_K5-Pad3_ GNDA 47k
R55 Net-_K5-Pad6_ /IN3R X
R54 Net-_K5-Pad6_ GNDA 47k
D14 Net-_D13-Pad2_ Net-_D14-Pad2_ LED
R56 Net-_D14-Pad2_ VDD 10k
P16 /IN3L GNDA RSA-IN3L
P17 /IN3R GNDA RSA-IN3R
Q5 Net-_Q5-Pad1_ GND Net-_D13-Pad2_ BC817
K5 VDD NC_10 Net-_K5-Pad3_ /IN13-L /IN13-R Net-_K5-Pad6_ NC_11 Net-_D13-Pad2_ G6K-2F
U9 SubL SubL Net-_C31-Pad2_ +15V Net-_C27-Pad2_ Net-_R38-Pad2_ Net-_R40-Pad1_ Net-_R41-Pad1_ Net-_R39-Pad2_ Net-_C28-Pad2_ -15V Net-_C32-Pad2_ SubR SubR TL074
J1 GNDA OUT-R CONN_01X02
J6 GNDA OUT-L CONN_01X02
J2 /OUT-TB-L GNDA CONN_01X02
J3 /OUT-TB-R GNDA CONN_01X02
J4 GNDA /OUT-SR CONN_01X02
J5 GNDA /OUT-SL CONN_01X02
R58 GNDPWR GNDA 0
.end
