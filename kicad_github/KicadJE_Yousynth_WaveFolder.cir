.title KiCad schematic
C3 GND +12V 100n
C1 GND +12V 1u
C4 GND -12V 100n
C2 GND -12V 1u
D1 +12V GND 1N1007
D2 GND -12V 1N1007
R11 Net-_Q402-Pad1_ Net-_R11-Pad2_ 22k
U401 Net-_R11-Pad2_ Net-_R5-Pad2_ GND -12V Net-_R14-Pad1_ Net-_R13-Pad1_ Output_VCA +12V TL072
P401 -12V -12V GND GND GND GND GND GND +12V +12V Doepfer_Power_10pin
J3 GND Net-_J3-PadT_ Output
J1 GND Net-_J1-PadT_ GND CV
R10 Net-_J1-PadT_ CV_Fold 10k
D5 +12V CV_Fold 1N1007
D6 CV_Fold GND 1N1007
J2 GND Net-_J2-PadT_ GND Input
R7 Net-_J2-PadT_ Input_Fold 10k
D3 +12V Input_Fold 1N1007
D4 Input_Fold -12V 1N1007
R15 Output_Fold Net-_J3-PadT_ 470R
U402 Net-_D416-Pad1_ Net-_C407-Pad1_ GND +12V GND Net-_C406-Pad2_ Net-_R406-Pad2_ Net-_D426-Pad1_ Net-_D422-Pad2_ GND -12V GND Net-_R430-Pad1_ Net-_C408-Pad1_ TL074
H401 2,2mm
H402 2,2mm
R403 -12V Net-_D405-Pad1_ 12K
D405 Net-_D405-Pad1_ GND LED
Q401 Net-_Q401-Pad1_ Net-_C405-Pad1_ Net-_Q401-Pad3_ Net-_Q401-Pad1_ GND Net-_Q401-Pad6_ UMX1N
Q402 Net-_Q402-Pad1_ Net-_Q402-Pad2_ GND SS9014
R420 Net-_Q402-Pad2_ Net-_Q401-Pad1_ 33k
R414 GND Net-_C405-Pad1_ 680R
R425 -12V Net-_Q402-Pad2_ 15k
R435 Net-_D426-Pad1_ Net-_R432-Pad1_ Open
RV404 -12V Net-_R12-Pad1_ +12V 50k
TP401 Net-_C405-Pad1_ Input
C408 Net-_C408-Pad1_ Output_Fold 22u Opt
C405 Net-_C405-Pad1_ Net-_C405-Pad2_ 1u/0R
R12 Net-_R12-Pad1_ Net-_Q402-Pad1_ 22k
R9 Net-_R11-Pad2_ Net-_R5-Pad2_ 100k
RV3 +12V Net-_R5-Pad1_ GND 100k Range
R5 Net-_R5-Pad1_ Net-_R5-Pad2_ 100k
R6 Net-_R5-Pad2_ Net-_R6-Pad2_ 68k
RV2 CV_Fold Net-_R6-Pad2_ GND 100k CV
R8 Net-_C405-Pad2_ Input_Fold 100k
RV401 Net-_R408-Pad2_ +12V Net-_R407-Pad2_ 1k
R408 Net-_Q401-Pad3_ Net-_R408-Pad2_ 15k 1%
R407 Net-_Q401-Pad6_ Net-_R407-Pad2_ 15k 1%
R13 Net-_R13-Pad1_ Net-_Q401-Pad6_ 10k 1%
R14 Net-_R14-Pad1_ Net-_Q401-Pad3_ 10k 1%
R18 Output_VCA Net-_R13-Pad1_ 100k 1%
R17 GND Net-_R14-Pad1_ 100k 1%
J4 GND Net-_J4-PadT_ VCA Out
R16 Output_VCA Net-_J4-PadT_ 470R
R1 Net-_D422-Pad2_ Output_VCA 100k
R2 Net-_D426-Pad1_ Net-_D422-Pad2_ 100k
R3 Net-_D426-Pad1_ Net-_D422-Pad1_ 33k
R4 GND Net-_D422-Pad1_ 2k7
D423 Net-_D422-Pad2_ Net-_D422-Pad1_ LL4148
D422 Net-_D422-Pad1_ Net-_D422-Pad2_ LL4148
RV1 Net-_R428-Pad1_ Net-_R432-Pad1_ Net-_D426-Pad1_ 100k Shape
R432 Net-_R432-Pad1_ Net-_R428-Pad1_ 0R
D427 Net-_D424-Pad2_ Net-_D426-Pad1_ LL4148
D426 Net-_D426-Pad1_ Net-_D424-Pad2_ LL4148
R438 Net-_D424-Pad2_ Net-_C407-Pad1_ 15k
D424 Net-_D420-Pad1_ Net-_D424-Pad2_ LL4148
D425 Net-_D424-Pad2_ Net-_D420-Pad1_ LL4148
R434 Net-_D420-Pad1_ Net-_C406-Pad2_ 15k
D421 Net-_D418-Pad2_ Net-_D420-Pad1_ LL4148
D420 Net-_D420-Pad1_ Net-_D418-Pad2_ LL4148
R431 Net-_D418-Pad2_ Net-_C407-Pad1_ 15k
D418 Net-_D414-Pad1_ Net-_D418-Pad2_ LL4148
D419 Net-_D418-Pad2_ Net-_D414-Pad1_ LL4148
R429 Net-_D414-Pad1_ Net-_C406-Pad2_ 15k
D415 Net-_D412-Pad2_ Net-_D414-Pad1_ LL4148
D414 Net-_D414-Pad1_ Net-_D412-Pad2_ LL4148
R427 Net-_D412-Pad2_ Net-_C407-Pad1_ 15k
D412 Net-_C407-Pad2_ Net-_D412-Pad2_ LL4148
D413 Net-_D412-Pad2_ Net-_C407-Pad2_ LL4148
R424 Net-_C407-Pad2_ Net-_C406-Pad2_ 15k
D411 Net-_C406-Pad1_ Net-_C407-Pad2_ LL4148
D410 Net-_C407-Pad2_ Net-_C406-Pad1_ LL4148
R419 Net-_C406-Pad1_ Net-_C407-Pad1_ 15k
D408 Net-_D408-Pad1_ Net-_C406-Pad1_ LL4148
D409 Net-_C406-Pad1_ Net-_D408-Pad1_ LL4148
R416 Net-_D408-Pad1_ Net-_C406-Pad2_ 15k
C406 Net-_C406-Pad1_ Net-_C406-Pad2_ 10n opt
C407 Net-_C407-Pad1_ Net-_C407-Pad2_ 10n opt
R411 Net-_R406-Pad2_ Net-_C407-Pad1_ 5k6
R406 Net-_C406-Pad2_ Net-_R406-Pad2_ 5k6
R428 Net-_R428-Pad1_ Net-_C406-Pad2_ 27k
D417 Net-_C407-Pad1_ Net-_D416-Pad1_ LL4148
D416 Net-_D416-Pad1_ Net-_C407-Pad1_ LL4148
R426 Net-_C407-Pad1_ Net-_D416-Pad1_ 56k
R433 Net-_D416-Pad1_ Net-_R430-Pad1_ 5k6
R430 Net-_R430-Pad1_ Net-_C408-Pad1_ 56k
.end
