.title KiCad schematic
U1 Net-_RV1-Pad2_ Net-_RV1-Pad3_ /Device0_FSR0 +3V3 /Device0_FSR1 Net-_RV2-Pad3_ Net-_RV2-Pad2_ Net-_RV3-Pad2_ Net-_RV3-Pad3_ /Device1_FSR0 GND /Device1_FSR1 Net-_RV4-Pad3_ Net-_RV4-Pad2_ OP495
R2 /Device0_FSR0 GND 1k
R5 /Device0_FSR1 GND 1k
R1 /Device1_FSR0 GND 1k
R6 /Device1_FSR1 GND 1k
RV2 GND Net-_RV2-Pad2_ Net-_RV2-Pad3_ R_POT
RV3 GND Net-_RV3-Pad2_ Net-_RV3-Pad3_ R_POT
RV4 GND Net-_RV4-Pad2_ Net-_RV4-Pad3_ R_POT
U2 Net-_RV1-Pad2_ Net-_RV2-Pad2_ Net-_RV3-Pad2_ Net-_RV4-Pad2_ NC_01 NC_02 GNDD /Chip_Select_ADC /MOSI /MISO /SCLK GND +3V3 +3V3 MCP3004
J1 +5V NC_03 NC_04 NC_05 GND NC_06 USB_B_Micro
U4 +5V Net-_R20-Pad1_ +3V3 /Device0_FSR0 /Device0_FSR1 MultigadgetDevice
U5 +5V Net-_R21-Pad2_ +3V3 /Device1_FSR0 /Device1_FSR1 MultigadgetDevice
U6 +5V Net-_Q5-Pad3_ +3V3 /Button0 LED_Button_connector
U7 +5V Net-_Q6-Pad3_ +3V3 /Button1 LED_Button_connector
R20 Net-_R20-Pad1_ Net-_Q1-Pad3_ 150
R21 Net-_Q2-Pad3_ Net-_R21-Pad2_ 150
U8 +5V Net-_Q3-Pad3_ +3V3 /Reward0Button LED_Button_connector
U9 +5V Net-_Q4-Pad3_ +3V3 /Reward1Button LED_Button_connector
J3 /Reward0 GND Conn_01x02
J4 /Reward1 GND Conn_01x02
J2 NC_07 NC_08 /Button0 NC_09 /Button0LED GNDD NC_10 /Button1 NC_11 /Button1LED /Reward0LED /Reward0Button NC_12 NC_13 /Reward1LED /Reward1Button NC_14 NC_15 /MOSI NC_16 /MISO NC_17 /SCLK /Chip_Select_ADC NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 /Device1LED NC_25 NC_26 NC_27 /Device0LED NC_28 /Reward0 GND /Reward1 Raspberry_Pi_2_3
U3 GND +3V3 +5V AZ1117-3.3
Q1 /Device0LED GND Net-_Q1-Pad3_ BSN20
Q2 /Device1LED GND Net-_Q2-Pad3_ BSN20
Q4 /Reward1LED GND Net-_Q4-Pad3_ BSN20
Q3 /Reward0LED GND Net-_Q3-Pad3_ BSN20
Q5 /Button0LED GND Net-_Q5-Pad3_ BSN20
Q6 /Button1LED GND Net-_Q6-Pad3_ BSN20
RV1 GND Net-_RV1-Pad2_ Net-_RV1-Pad3_ R_POT
.end
