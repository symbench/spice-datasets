.title KiCad schematic
J1 /5V0 /5V0 /5V0 /5V0 /GND /GND /GND /GND /PSU_PGOOD /1V0_EN /2V5_EN /1V8_EN /I2C_SCL /I2C_SDA /JTAG_TDI /MGMT_MDC /JTAG_TCK /MGMT_MDIO /JTAG_TMS /JTAG_TDO /PHY_RST_N /SGMII6_RX_N /PHYs/SGMII0_TX_P /SGMII6_RX_P /PHYs/SGMII0_TX_N /PHYs/SGMII6_TX_N /SGMII0_RX_P /PHYs/SGMII6_TX_P /SGMII0_RX_N /PHYs/SGMII7_TX_P /SGMII1_RX_N /PHYs/SGMII7_TX_N /SGMII1_RX_P /SGMII7_RX_P /PHYs/SGMII1_TX_N /SGMII7_RX_N /PHYs/SGMII1_TX_P /SGMII4_RX_N /PHYs/SGMII2_TX_P /SGMII4_RX_P /PHYs/SGMII2_TX_N /PHYs/SGMII4_TX_N /SGMII2_RX_P /PHYs/SGMII4_TX_P /SGMII2_RX_N /PHYs/SGMII5_TX_P /SGMII3_RX_N /PHYs/SGMII5_TX_N /SGMII3_RX_P /SGMII5_RX_P /PHYs/SGMII3_TX_N /SGMII5_RX_N /PHYs/SGMII3_TX_P /GND CONN_LATENTRED_LINECARD_DEVICE
R155 /3V3 /I2C_SDA 4.7k
R156 /3V3 /I2C_SCL 4.7k
MH1 NC_01 HOLE_4_40
MH2 NC_02 HOLE_4_40
MH3 NC_03 HOLE_4_40
MH4 NC_04 HOLE_4_40
R159 /GND /PHY_RST_N 1K
U2 /Power Supply/1V0_FB /5V0 /Power Supply/1V0_SW /Power Supply/1V0_SW /5V0 /5V0 /5V0 /5V0 /Power Supply/1V0_SW NC_05 NC_06 NC_07 /GND /GND /PSU_PGOOD /GND /5V0 /GND /2V5_EN Net-_R11-Pad2_ /5V0 /Power Supply/2V5_SW /Power Supply/2V5_SW /5V0 /5V0 Net-_R12-Pad2_ /5V0 /Power Supply/1V8_SW /Power Supply/1V8_SW /5V0 /5V0 /GND /1V8_EN /5V0 /5V0 /Power Supply/SMPS_TEMP /GND /1V0_EN /GND LTC3374-QFN
L1 /Power Supply/1V0_DECOUPLE /Power Supply/1V0_SW NR6028T2R2N
U4 /GND /GND /3V3 /3V3 /GND /Power Supply/SMPS_TEMP /I2C_SCL /I2C_SDA /GND LTC2451
R13 /3V3 /PSU_PGOOD 4.7k
L2 /Power Supply/2V5_DECOUPLE /Power Supply/2V5_SW NR6028T2R2N
L3 /Power Supply/1V8_DECOUPLE /Power Supply/1V8_SW NR6028T2R2N
U1 /3V3 /GND /5V0 /GND MCP1703T-3302E
C5 /3V3 /GND 0.47 uF
U3 /I2C_SDA /GND /3V3 /I2C_SCL SI7050
C6 /3V3 /GND 0.47 uF
U7 /GND /3V3 NC_08 /I2C_SDA /I2C_SCL /3V3 /GND /PHYs/1V0 Net-_C3-Pad2_ Net-_C3-Pad1_ INA226
R7 /Power Supply/1V0_SHUNT_LO /PHYs/1V0 /Power Supply/1V0_SHUNT_HI /Power Supply/1V0_DECOUPLE 10m
R8 /Power Supply/2V5_SHUNT_LO /PHYs/2V5 /Power Supply/2V5_SHUNT_HI /Power Supply/2V5_DECOUPLE 10m
R9 /Power Supply/1V8_SHUNT_LO /PHYs/1V8 /Power Supply/1V8_SHUNT_HI /Power Supply/1V8_DECOUPLE 10m
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 0.47 uF
U6 /GND /I2C_SDA NC_09 /I2C_SDA /I2C_SCL /3V3 /GND /PHYs/1V8 Net-_C2-Pad2_ Net-_C2-Pad1_ INA226
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 0.47 uF
U5 /GND /I2C_SCL NC_10 /I2C_SDA /I2C_SCL /3V3 /GND /PHYs/2V5 Net-_C1-Pad2_ Net-_C1-Pad1_ INA226
R14 /Power Supply/2V5_SHUNT_HI Net-_C1-Pad1_ 2
R15 /Power Supply/2V5_SHUNT_LO Net-_C1-Pad2_ 2
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 0.47 uF
C9 /3V3 /GND 4.7 uF
C7 /3V3 /GND 0.47 uF
C10 /3V3 /GND 0.47 uF
C11 /3V3 /GND 0.47 uF
R16 /Power Supply/1V8_SHUNT_HI Net-_C2-Pad1_ 2
R17 /Power Supply/1V8_SHUNT_LO Net-_C2-Pad2_ 2
R18 /Power Supply/1V0_SHUNT_HI Net-_C3-Pad1_ 2
R19 /Power Supply/1V0_SHUNT_LO Net-_C3-Pad2_ 2
R4 /Power Supply/1V0_FB /Power Supply/1V0_SENSE 255k
R10 /GND /Power Supply/1V0_FB 1.02M
R1 /Power Supply/1V0_SENSE /PHYs/1V0 0
R5 Net-_R11-Pad2_ /Power Supply/2V5_SENSE 1.02M
R11 /GND Net-_R11-Pad2_ 475k
R2 /Power Supply/2V5_SENSE /PHYs/2V5 0
R6 Net-_R12-Pad2_ /Power Supply/1V8_SENSE 806k
R12 /GND Net-_R12-Pad2_ 649k
R3 /Power Supply/1V8_SENSE /PHYs/1V8 0
C33 /5V0 /GND 47 uF
C36 /5V0 /GND 47 uF
C38 /5V0 /GND 47 uF
C41 /5V0 /GND 0.47 uF
C43 /5V0 /GND 4.7 uF
C34 /Power Supply/1V8_DECOUPLE /GND 47 uF
C39 /Power Supply/2V5_DECOUPLE /GND 47 uF
C35 /5V0 /GND 4.7 uF
C37 /3V3 /GND 4.7 uF
C40 /3V3 /GND 0.47 uF
C42 /Power Supply/2V5_DECOUPLE /GND 47 uF
C44 /Power Supply/1V0_DECOUPLE /GND 47 uF
C45 /Power Supply/1V0_DECOUPLE /GND 47 uF
R152 /GND /1V0_EN 10K
R153 /GND /1V8_EN 10K
R154 /GND /2V5_EN 10K
U8 /PHYs/ETH0_A_P /PHYs/ETH0_A_N /PHYs/A2V5_1 /PHYs/ETH0_B_P /PHYs/ETH0_B_N /PHYs/A1V0_1 /PHYs/ETH0_C_P /PHYs/ETH0_C_N /PHYs/A2V5_1 /PHYs/ETH0_D_P /PHYs/ETH0_D_N Net-_R20-Pad2_ /PHYs/A1V8_1 NC_11 /PHYs/CLK_25MHZ_0 /MGMT_MDC /MGMT_MDIO NC_12 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_0 /JTAG_TMS /JTAG_TDI /PHYs/A1V0_1 NC_13 NC_14 /PHYs/SGMII0_TX_C_P /PHYs/SGMII0_TX_C_N NC_15 /PHYs/1V8 /PHYs/A1V0_1 NC_16 NC_17 NC_18 /PHYs/SGMII0_RX_C_P /PHYs/SGMII0_RX_C_N NC_19 /PHYs/RX_CTRL_0 NC_20 NC_21 /PHYs/1V8 /PHYs/A1V0_1 /PHY_RST_N Net-_R21-Pad2_ NC_22 /PHYs/LED_1_0 /PHYs/LED_0_0 /PHYs/A1V8_1 /GND DP83867
R20 /GND Net-_R20-Pad2_ 11K
R21 /PHYs/1V8 Net-_R21-Pad2_ 10k
C12 /PHYs/SGMII0_TX_C_P /PHYs/SGMII0_TX_P 0.1 uF
C13 /PHYs/SGMII0_TX_C_N /PHYs/SGMII0_TX_N 0.1 uF
C14 /PHYs/SGMII0_RX_C_P /SGMII0_RX_P 0.1 uF
C15 /PHYs/SGMII0_RX_C_N /SGMII0_RX_N 0.1 uF
C21 /PHYs/A2V5_1 /GND 4.7 uF
C25 /PHYs/A2V5_1 /GND 0.47 uF
C28 /PHYs/A2V5_1 /GND 0.47 uF
C22 /PHYs/A1V8_1 /GND 4.7 uF
C26 /PHYs/A1V8_1 /GND 0.47 uF
C29 /PHYs/A1V8_1 /GND 0.47 uF
C23 /PHYs/A1V0_1 /GND 4.7 uF
C27 /PHYs/A1V0_1 /GND 0.47 uF
C30 /PHYs/A1V0_1 /GND 0.47 uF
C31 /PHYs/A1V0_1 /GND 0.47 uF
C32 /PHYs/A1V0_1 /GND 0.47 uF
C16 /PHYs/1V8 /GND 0.47 uF
C20 /PHYs/1V8 /GND 0.47 uF
C24 /PHYs/1V8 /GND 0.47 uF
R28 /PHYs/1V8 /MGMT_MDIO 2.0K
R22 /PHYs/RX_CTRL_0 /PHYs/1V8 5.76K
R23 /GND /PHYs/RX_CTRL_0 2.49K
Q1 Net-_Q1-PadD1_ Net-_Q1-PadD2_ /PHYs/LED_1_0 /PHYs/LED_0_0 /GND /GND SSM6N58NU
R24 /PHYs/LED1_0_N Net-_Q1-PadD1_ 470
R27 /PHYs/LED0_0_N Net-_Q1-PadD2_ 470
R25 /PHYs/1V8 /PHYs/LED_0_0 10K
R26 /PHYs/LED_0_0 /GND 2.49K
L7 Net-_L7-Pad1_ /PHYs/ETH0_AM_P /PHYs/ETH0_AM_N Net-_L7-Pad4_ /PHYs/ETH0_BM_N /PHYs/ETH0_BM_P Net-_L7-Pad7_ /PHYs/ETH0_CM_P /PHYs/ETH0_CM_N Net-_L7-Pad10_ /PHYs/ETH0_DM_N /PHYs/ETH0_DM_P /PHYs/ETH0_D_N /PHYs/ETH0_D_P Net-_C46-Pad2_ /PHYs/ETH0_C_N /PHYs/ETH0_C_P Net-_C47-Pad2_ /PHYs/ETH0_B_N /PHYs/ETH0_B_P Net-_C48-Pad2_ /PHYs/ETH0_A_N /PHYs/ETH0_A_P Net-_C49-Pad2_ BOURNS_PT6120EL
C49 /GND Net-_C49-Pad2_ 0.1 uF
C48 /GND Net-_C48-Pad2_ 0.1 uF
C47 /GND Net-_C47-Pad2_ 0.1 uF
C46 /GND Net-_C46-Pad2_ 0.1 uF
R29 Net-_C50-Pad2_ Net-_L7-Pad1_ 75
R30 Net-_C50-Pad2_ Net-_L7-Pad4_ 75
R31 Net-_C50-Pad2_ Net-_L7-Pad7_ 75
R32 Net-_C50-Pad2_ Net-_L7-Pad10_ 75
C50 /PHYs/SHIELD Net-_C50-Pad2_ 10 nF 2 kV
J2 /PHYs/ETH0_AM_P /PHYs/ETH0_AM_N /PHYs/ETH0_BM_P /PHYs/ETH0_CM_P /PHYs/ETH0_CM_N /PHYs/ETH0_BM_N /PHYs/ETH0_DM_P /PHYs/ETH0_DM_N /PHYs/3V3 /PHYs/LED0_0_N /PHYs/3V3 /PHYs/LED1_0_N /PHYs/ETH1_AM_P /PHYs/ETH1_AM_N /PHYs/ETH1_BM_P /PHYs/ETH1_CM_P /PHYs/ETH1_CM_N /PHYs/ETH1_BM_N /PHYs/ETH1_DM_P /PHYs/ETH1_DM_N /PHYs/3V3 /PHYs/LED0_1_N /PHYs/3V3 /PHYs/LED1_1_N /PHYs/ETH2_AM_P /PHYs/ETH2_AM_N /PHYs/ETH2_BM_P /PHYs/ETH2_CM_P /PHYs/ETH2_CM_N /PHYs/ETH2_BM_N /PHYs/ETH2_DM_P /PHYs/ETH2_DM_N /PHYs/3V3 /PHYs/LED0_2_N /PHYs/3V3 /PHYs/LED1_2_N /PHYs/ETH3_AM_P /PHYs/ETH3_AM_N /PHYs/ETH3_BM_P /PHYs/ETH3_CM_P /PHYs/ETH3_CM_N /PHYs/ETH3_BM_N /PHYs/ETH3_DM_P /PHYs/ETH3_DM_N /PHYs/3V3 /PHYs/LED0_3_N /PHYs/3V3 /PHYs/LED1_3_N /PHYs/ETH4_AM_P /PHYs/ETH4_AM_N /PHYs/ETH4_BM_P /PHYs/ETH4_CM_P /PHYs/ETH4_CM_N /PHYs/ETH4_BM_N /PHYs/ETH4_DM_P /PHYs/ETH4_DM_N /PHYs/3V3 /PHYs/LED0_4_N /PHYs/3V3 /PHYs/LED1_4_N /PHYs/ETH5_AM_P /PHYs/ETH5_AM_N /PHYs/ETH5_BM_P /PHYs/ETH5_CM_P /PHYs/ETH5_CM_N /PHYs/ETH5_BM_N /PHYs/ETH5_DM_P /PHYs/ETH5_DM_N /PHYs/3V3 /PHYs/LED0_5_N /PHYs/3V3 /PHYs/LED1_5_N /PHYs/ETH6_AM_P /PHYs/ETH6_AM_N /PHYs/ETH6_BM_P /PHYs/ETH6_CM_P /PHYs/ETH6_CM_N /PHYs/ETH6_BM_N /PHYs/ETH6_DM_P /PHYs/ETH6_DM_N /PHYs/3V3 /PHYs/LED0_6_N /PHYs/3V3 /PHYs/LED1_6_N /PHYs/ETH7_AM_P /PHYs/ETH7_AM_N /PHYs/ETH7_BM_P /PHYs/ETH7_CM_P /PHYs/ETH7_CM_N /PHYs/ETH7_BM_N /PHYs/ETH7_DM_P /PHYs/ETH7_DM_N /PHYs/3V3 /PHYs/LED0_7_N /PHYs/3V3 /PHYs/LED1_7_N /PHYs/SHIELD STEWART_SS_74500_024
U9 /PHYs/ETH1_A_P /PHYs/ETH1_A_N /PHYs/A2V5_1 /PHYs/ETH1_B_P /PHYs/ETH1_B_N /PHYs/A1V0_1 /PHYs/ETH1_C_P /PHYs/ETH1_C_N /PHYs/A2V5_1 /PHYs/ETH1_D_P /PHYs/ETH1_D_N Net-_R33-Pad2_ /PHYs/A1V8_1 NC_23 /PHYs/CLK_25MHZ_1 /MGMT_MDC /MGMT_MDIO NC_24 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_1 /JTAG_TMS /PHYs/JTAG_TDO_0 /PHYs/A1V0_1 NC_25 NC_26 /PHYs/SGMII1_TX_C_P /PHYs/SGMII1_TX_C_N NC_27 /PHYs/1V8 /PHYs/A1V0_1 NC_28 /PHYs/RX_D0_1 NC_29 /PHYs/SGMII1_RX_C_P /PHYs/SGMII1_RX_C_N NC_30 /PHYs/RX_CTRL_1 NC_31 NC_32 /PHYs/1V8 /PHYs/A1V0_1 /PHY_RST_N Net-_R34-Pad2_ NC_33 /PHYs/LED_1_1 /PHYs/LED_0_1 /PHYs/A1V8_1 /GND DP83867
L8 /PHYs/A2V5_1 /PHYs/2V5 600R
L10 /PHYs/A1V0_1 /PHYs/1V0 600R
L9 /PHYs/A1V8_1 /PHYs/1V8 600R
R33 /GND Net-_R33-Pad2_ 11K
R34 /PHYs/1V8 Net-_R34-Pad2_ 10k
C51 /PHYs/SGMII1_TX_C_P /PHYs/SGMII1_TX_P 0.1 uF
C52 /PHYs/SGMII1_TX_C_N /PHYs/SGMII1_TX_N 0.1 uF
C53 /PHYs/SGMII1_RX_C_P /SGMII1_RX_P 0.1 uF
C54 /PHYs/SGMII1_RX_C_N /SGMII1_RX_N 0.1 uF
C64 /PHYs/2V5 /GND 4.7 uF
C78 /PHYs/A2V5_1 /GND 4.7 uF
C93 /PHYs/A2V5_1 /GND 0.47 uF
C105 /PHYs/A2V5_1 /GND 0.47 uF
C65 /PHYs/1V8 /GND 4.7 uF
C79 /PHYs/A1V8_1 /GND 4.7 uF
C94 /PHYs/A1V8_1 /GND 0.47 uF
C106 /PHYs/A1V8_1 /GND 0.47 uF
C66 /PHYs/1V0 /GND 4.7 uF
C80 /PHYs/A1V0_1 /GND 4.7 uF
C95 /PHYs/A1V0_1 /GND 0.47 uF
C107 /PHYs/A1V0_1 /GND 0.47 uF
C117 /PHYs/A1V0_1 /GND 0.47 uF
C123 /PHYs/A1V0_1 /GND 0.47 uF
C63 /PHYs/1V8 /GND 0.47 uF
C75 /PHYs/1V8 /GND 0.47 uF
C87 /PHYs/1V8 /GND 0.47 uF
R39 /PHYs/RX_CTRL_1 /PHYs/1V8 5.76K
R45 /GND /PHYs/RX_CTRL_1 2.49K
Q2 Net-_Q2-PadD1_ Net-_Q2-PadD2_ /PHYs/LED_1_1 /PHYs/LED_0_1 /GND /GND SSM6N58NU
R57 /PHYs/LED1_1_N Net-_Q2-PadD1_ 470
Q3 Net-_Q3-PadD1_ Net-_Q3-PadD2_ /PHYs/LED_1_2 /PHYs/LED_0_2 /GND /GND SSM6N58NU
R71 /PHYs/LED0_1_N Net-_Q2-PadD2_ 470
R65 /PHYs/1V8 /PHYs/LED_0_1 10K
R66 /PHYs/LED_0_1 /GND 2.49K
L17 Net-_L17-Pad1_ /PHYs/ETH1_AM_P /PHYs/ETH1_AM_N Net-_L17-Pad4_ /PHYs/ETH1_BM_N /PHYs/ETH1_BM_P Net-_L17-Pad7_ /PHYs/ETH1_CM_P /PHYs/ETH1_CM_N Net-_L17-Pad10_ /PHYs/ETH1_DM_N /PHYs/ETH1_DM_P /PHYs/ETH1_D_N /PHYs/ETH1_D_P Net-_C90-Pad2_ /PHYs/ETH1_C_N /PHYs/ETH1_C_P Net-_C102-Pad2_ /PHYs/ETH1_B_N /PHYs/ETH1_B_P Net-_C114-Pad2_ /PHYs/ETH1_A_N /PHYs/ETH1_A_P Net-_C120-Pad2_ BOURNS_PT6120EL
C120 /GND Net-_C120-Pad2_ 0.1 uF
C114 /GND Net-_C114-Pad2_ 0.1 uF
C102 /GND Net-_C102-Pad2_ 0.1 uF
C90 /GND Net-_C90-Pad2_ 0.1 uF
R50 Net-_C126-Pad2_ Net-_L17-Pad1_ 75
R53 Net-_C126-Pad2_ Net-_L17-Pad4_ 75
R56 Net-_C126-Pad2_ Net-_L17-Pad7_ 75
R62 Net-_C126-Pad2_ Net-_L17-Pad10_ 75
C126 /PHYs/SHIELD Net-_C126-Pad2_ 10 nF 2 kV
R40 /PHYs/RX_D0_1 /PHYs/1V8 10K
R46 /GND /PHYs/RX_D0_1 2.49K
U10 /PHYs/ETH2_A_P /PHYs/ETH2_A_N /PHYs/A2V5_3 /PHYs/ETH2_B_P /PHYs/ETH2_B_N /PHYs/A1V0_3 /PHYs/ETH2_C_P /PHYs/ETH2_C_N /PHYs/A2V5_3 /PHYs/ETH2_D_P /PHYs/ETH2_D_N Net-_R35-Pad2_ /PHYs/A1V8_3 NC_34 /PHYs/CLK_25MHZ_2 /MGMT_MDC /MGMT_MDIO NC_35 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_2 /JTAG_TMS /PHYs/JTAG_TDO_1 /PHYs/A1V0_3 NC_36 NC_37 /PHYs/SGMII2_TX_C_P /PHYs/SGMII2_TX_C_N NC_38 /PHYs/1V8 /PHYs/A1V0_3 NC_39 /PHYs/RX_D0_2 NC_40 /PHYs/SGMII2_RX_C_P /PHYs/SGMII2_RX_C_N NC_41 /PHYs/RX_CTRL_2 NC_42 NC_43 /PHYs/1V8 /PHYs/A1V0_3 /PHY_RST_N Net-_R36-Pad2_ NC_44 /PHYs/LED_1_2 /PHYs/LED_0_2 /PHYs/A1V8_3 /GND DP83867
R35 /GND Net-_R35-Pad2_ 11K
R36 /PHYs/1V8 Net-_R36-Pad2_ 10k
C55 /PHYs/SGMII2_TX_C_P /PHYs/SGMII2_TX_P 0.1 uF
C56 /PHYs/SGMII2_TX_C_N /PHYs/SGMII2_TX_N 0.1 uF
C57 /PHYs/SGMII2_RX_C_P /SGMII2_RX_P 0.1 uF
C58 /PHYs/SGMII2_RX_C_N /SGMII2_RX_N 0.1 uF
C81 /PHYs/A2V5_3 /GND 4.7 uF
C96 /PHYs/A2V5_3 /GND 0.47 uF
C108 /PHYs/A2V5_3 /GND 0.47 uF
C82 /PHYs/A1V8_3 /GND 4.7 uF
C97 /PHYs/A1V8_3 /GND 0.47 uF
C109 /PHYs/A1V8_3 /GND 0.47 uF
C83 /PHYs/A1V0_3 /GND 4.7 uF
C98 /PHYs/A1V0_3 /GND 0.47 uF
C110 /PHYs/A1V0_3 /GND 0.47 uF
C118 /PHYs/A1V0_3 /GND 0.47 uF
C124 /PHYs/A1V0_3 /GND 0.47 uF
C67 /PHYs/1V8 /GND 0.47 uF
C76 /PHYs/1V8 /GND 0.47 uF
C88 /PHYs/1V8 /GND 0.47 uF
R41 /PHYs/RX_CTRL_2 /PHYs/1V8 5.76K
R47 /GND /PHYs/RX_CTRL_2 2.49K
R59 /PHYs/LED1_2_N Net-_Q3-PadD1_ 470
Q4 Net-_Q4-PadD1_ Net-_Q4-PadD2_ /PHYs/LED_1_3 /PHYs/LED_0_3 /GND /GND SSM6N58NU
R72 /PHYs/LED0_2_N Net-_Q3-PadD2_ 470
R67 /PHYs/1V8 /PHYs/LED_0_2 10K
R68 /PHYs/LED_0_2 /GND 2.49K
L18 Net-_L18-Pad1_ /PHYs/ETH2_AM_P /PHYs/ETH2_AM_N Net-_L18-Pad4_ /PHYs/ETH2_BM_N /PHYs/ETH2_BM_P Net-_L18-Pad7_ /PHYs/ETH2_CM_P /PHYs/ETH2_CM_N Net-_L18-Pad10_ /PHYs/ETH2_DM_N /PHYs/ETH2_DM_P /PHYs/ETH2_D_N /PHYs/ETH2_D_P Net-_C91-Pad2_ /PHYs/ETH2_C_N /PHYs/ETH2_C_P Net-_C103-Pad2_ /PHYs/ETH2_B_N /PHYs/ETH2_B_P Net-_C115-Pad2_ /PHYs/ETH2_A_N /PHYs/ETH2_A_P Net-_C121-Pad2_ BOURNS_PT6120EL
C121 /GND Net-_C121-Pad2_ 0.1 uF
C115 /GND Net-_C115-Pad2_ 0.1 uF
C103 /GND Net-_C103-Pad2_ 0.1 uF
C91 /GND Net-_C91-Pad2_ 0.1 uF
R51 Net-_C127-Pad2_ Net-_L18-Pad1_ 75
R54 Net-_C127-Pad2_ Net-_L18-Pad4_ 75
R58 Net-_C127-Pad2_ Net-_L18-Pad7_ 75
R63 Net-_C127-Pad2_ Net-_L18-Pad10_ 75
C127 /PHYs/SHIELD Net-_C127-Pad2_ 10 nF 2 kV
R42 /PHYs/RX_D0_2 /PHYs/1V8 5.76k
R48 /GND /PHYs/RX_D0_2 2.49K
U11 /PHYs/ETH3_A_P /PHYs/ETH3_A_N /PHYs/A2V5_3 /PHYs/ETH3_B_P /PHYs/ETH3_B_N /PHYs/A1V0_3 /PHYs/ETH3_C_P /PHYs/ETH3_C_N /PHYs/A2V5_3 /PHYs/ETH3_D_P /PHYs/ETH3_D_N Net-_R37-Pad2_ /PHYs/A1V8_3 NC_45 /PHYs/CLK_25MHZ_3 /MGMT_MDC /MGMT_MDIO NC_46 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_3 /JTAG_TMS /PHYs/JTAG_TDO_2 /PHYs/A1V0_3 NC_47 NC_48 /PHYs/SGMII3_TX_C_P /PHYs/SGMII3_TX_C_N NC_49 /PHYs/1V8 /PHYs/A1V0_3 NC_50 /PHYs/RX_D0_3 NC_51 /PHYs/SGMII3_RX_C_P /PHYs/SGMII3_RX_C_N NC_52 /PHYs/RX_CTRL_3 NC_53 NC_54 /PHYs/1V8 /PHYs/A1V0_3 /PHY_RST_N Net-_R38-Pad2_ NC_55 /PHYs/LED_1_3 /PHYs/LED_0_3 /PHYs/A1V8_3 /GND DP83867
L14 /PHYs/A2V5_3 /PHYs/2V5 600R
L16 /PHYs/A1V0_3 /PHYs/1V0 600R
L15 /PHYs/A1V8_3 /PHYs/1V8 600R
R37 /GND Net-_R37-Pad2_ 11K
R38 /PHYs/1V8 Net-_R38-Pad2_ 10k
C59 /PHYs/SGMII3_TX_C_P /PHYs/SGMII3_TX_P 0.1 uF
C60 /PHYs/SGMII3_TX_C_N /PHYs/SGMII3_TX_N 0.1 uF
C61 /PHYs/SGMII3_RX_C_P /SGMII3_RX_P 0.1 uF
C62 /PHYs/SGMII3_RX_C_N /SGMII3_RX_N 0.1 uF
C72 /PHYs/2V5 /GND 4.7 uF
C84 /PHYs/A2V5_3 /GND 4.7 uF
C99 /PHYs/A2V5_3 /GND 0.47 uF
C111 /PHYs/A2V5_3 /GND 0.47 uF
C73 /PHYs/1V8 /GND 4.7 uF
C85 /PHYs/A1V8_3 /GND 4.7 uF
C100 /PHYs/A1V8_3 /GND 0.47 uF
C112 /PHYs/A1V8_3 /GND 0.47 uF
C74 /PHYs/1V0 /GND 4.7 uF
C86 /PHYs/A1V0_3 /GND 4.7 uF
C101 /PHYs/A1V0_3 /GND 0.47 uF
C113 /PHYs/A1V0_3 /GND 0.47 uF
C119 /PHYs/A1V0_3 /GND 0.47 uF
C125 /PHYs/A1V0_3 /GND 0.47 uF
C71 /PHYs/1V8 /GND 0.47 uF
C77 /PHYs/1V8 /GND 0.47 uF
C89 /PHYs/1V8 /GND 0.47 uF
R43 /PHYs/RX_CTRL_3 /PHYs/1V8 5.76K
R49 /GND /PHYs/RX_CTRL_3 2.49K
R61 /PHYs/LED1_3_N Net-_Q4-PadD1_ 470
R73 /PHYs/LED0_3_N Net-_Q4-PadD2_ 470
R69 /PHYs/1V8 /PHYs/LED_0_3 10K
R70 /PHYs/LED_0_3 /GND 2.49K
L19 Net-_L19-Pad1_ /PHYs/ETH3_AM_P /PHYs/ETH3_AM_N Net-_L19-Pad4_ /PHYs/ETH3_BM_N /PHYs/ETH3_BM_P Net-_L19-Pad7_ /PHYs/ETH3_CM_P /PHYs/ETH3_CM_N Net-_L19-Pad10_ /PHYs/ETH3_DM_N /PHYs/ETH3_DM_P /PHYs/ETH3_D_N /PHYs/ETH3_D_P Net-_C92-Pad2_ /PHYs/ETH3_C_N /PHYs/ETH3_C_P Net-_C104-Pad2_ /PHYs/ETH3_B_N /PHYs/ETH3_B_P Net-_C116-Pad2_ /PHYs/ETH3_A_N /PHYs/ETH3_A_P Net-_C122-Pad2_ BOURNS_PT6120EL
C122 /GND Net-_C122-Pad2_ 0.1 uF
C116 /GND Net-_C116-Pad2_ 0.1 uF
C104 /GND Net-_C104-Pad2_ 0.1 uF
C92 /GND Net-_C92-Pad2_ 0.1 uF
R52 Net-_C128-Pad2_ Net-_L19-Pad1_ 75
R55 Net-_C128-Pad2_ Net-_L19-Pad4_ 75
R60 Net-_C128-Pad2_ Net-_L19-Pad7_ 75
R64 Net-_C128-Pad2_ Net-_L19-Pad10_ 75
C128 /PHYs/SHIELD Net-_C128-Pad2_ 10 nF 2 kV
R44 /PHYs/RX_D0_3 /PHYs/1V8 2.49K
U12 /PHYs/ETH4_A_P /PHYs/ETH4_A_N /PHYs/A2V5_5 /PHYs/ETH4_B_P /PHYs/ETH4_B_N /PHYs/A1V0_5 /PHYs/ETH4_C_P /PHYs/ETH4_C_N /PHYs/A2V5_5 /PHYs/ETH4_D_P /PHYs/ETH4_D_N Net-_R74-Pad2_ /PHYs/A1V8_5 NC_56 /PHYs/CLK_25MHZ_4 /MGMT_MDC /MGMT_MDIO NC_57 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_4 /JTAG_TMS /PHYs/JTAG_TDO_3 /PHYs/A1V0_5 NC_58 NC_59 /PHYs/SGMII4_TX_C_P /PHYs/SGMII4_TX_C_N NC_60 /PHYs/1V8 /PHYs/A1V0_5 NC_61 NC_62 NC_63 /PHYs/SGMII4_RX_C_P /PHYs/SGMII4_RX_C_N NC_64 /PHYs/RX_CTRL_4 NC_65 NC_66 /PHYs/1V8 /PHYs/A1V0_5 /PHY_RST_N Net-_R75-Pad2_ NC_67 /PHYs/LED_1_4 /PHYs/LED_0_4 /PHYs/A1V8_5 /GND DP83867
R74 /GND Net-_R74-Pad2_ 11K
R75 /PHYs/1V8 Net-_R75-Pad2_ 10k
C129 /PHYs/SGMII4_TX_C_P /PHYs/SGMII4_TX_P 0.1 uF
C130 /PHYs/SGMII4_TX_C_N /PHYs/SGMII4_TX_N 0.1 uF
C131 /PHYs/SGMII4_RX_C_P /SGMII4_RX_P 0.1 uF
C132 /PHYs/SGMII4_RX_C_N /SGMII4_RX_N 0.1 uF
C165 /PHYs/A2V5_5 /GND 4.7 uF
C185 /PHYs/A2V5_5 /GND 0.47 uF
C201 /PHYs/A2V5_5 /GND 0.47 uF
C166 /PHYs/A1V8_5 /GND 4.7 uF
C186 /PHYs/A1V8_5 /GND 0.47 uF
C202 /PHYs/A1V8_5 /GND 0.47 uF
C167 /PHYs/A1V0_5 /GND 4.7 uF
C187 /PHYs/A1V0_5 /GND 0.47 uF
C203 /PHYs/A1V0_5 /GND 0.47 uF
C217 /PHYs/A1V0_5 /GND 0.47 uF
C225 /PHYs/A1V0_5 /GND 0.47 uF
C145 /PHYs/1V8 /GND 0.47 uF
C161 /PHYs/1V8 /GND 0.47 uF
C177 /PHYs/1V8 /GND 0.47 uF
R82 /PHYs/RX_CTRL_4 /PHYs/1V8 5.76K
R97 /GND /PHYs/RX_CTRL_4 2.49K
Q5 Net-_Q5-PadD1_ Net-_Q5-PadD2_ /PHYs/LED_1_4 /PHYs/LED_0_4 /GND /GND SSM6N58NU
R120 /PHYs/LED1_4_N Net-_Q5-PadD1_ 470
Q7 Net-_Q7-PadD1_ Net-_Q7-PadD2_ /PHYs/LED_1_5 /PHYs/LED_0_5 /GND /GND SSM6N58NU
R139 /PHYs/LED0_4_N Net-_Q5-PadD2_ 470
R131 /PHYs/1V8 /PHYs/LED_0_4 10K
R132 /PHYs/LED_0_4 /GND 2.49K
L32 Net-_L32-Pad1_ /PHYs/ETH4_AM_P /PHYs/ETH4_AM_N Net-_L32-Pad4_ /PHYs/ETH4_BM_N /PHYs/ETH4_BM_P Net-_L32-Pad7_ /PHYs/ETH4_CM_P /PHYs/ETH4_CM_N Net-_L32-Pad10_ /PHYs/ETH4_DM_N /PHYs/ETH4_DM_P /PHYs/ETH4_D_N /PHYs/ETH4_D_P Net-_C181-Pad2_ /PHYs/ETH4_C_N /PHYs/ETH4_C_P Net-_C197-Pad2_ /PHYs/ETH4_B_N /PHYs/ETH4_B_P Net-_C213-Pad2_ /PHYs/ETH4_A_N /PHYs/ETH4_A_P Net-_C221-Pad2_ BOURNS_PT6120EL
C221 /GND Net-_C221-Pad2_ 0.1 uF
C213 /GND Net-_C213-Pad2_ 0.1 uF
C197 /GND Net-_C197-Pad2_ 0.1 uF
C181 /GND Net-_C181-Pad2_ 0.1 uF
R111 Net-_C229-Pad2_ Net-_L32-Pad1_ 75
R115 Net-_C229-Pad2_ Net-_L32-Pad4_ 75
R119 Net-_C229-Pad2_ Net-_L32-Pad7_ 75
R127 Net-_C229-Pad2_ Net-_L32-Pad10_ 75
C229 /PHYs/SHIELD Net-_C229-Pad2_ 10 nF 2 kV
U13 /PHYs/ETH5_A_P /PHYs/ETH5_A_N /PHYs/A2V5_5 /PHYs/ETH5_B_P /PHYs/ETH5_B_N /PHYs/A1V0_5 /PHYs/ETH5_C_P /PHYs/ETH5_C_N /PHYs/A2V5_5 /PHYs/ETH5_D_P /PHYs/ETH5_D_N Net-_R76-Pad2_ /PHYs/A1V8_5 NC_68 /PHYs/CLK_25MHZ_5 /MGMT_MDC /MGMT_MDIO NC_69 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_5 /JTAG_TMS /PHYs/JTAG_TDO_4 /PHYs/A1V0_5 NC_70 NC_71 /PHYs/SGMII5_TX_C_P /PHYs/SGMII5_TX_C_N NC_72 /PHYs/1V8 /PHYs/A1V0_5 NC_73 /PHYs/RX_D0_5 NC_74 /PHYs/SGMII5_RX_C_P /PHYs/SGMII5_RX_C_N NC_75 /PHYs/RX_CTRL_5 NC_76 NC_77 /PHYs/1V8 /PHYs/A1V0_5 /PHY_RST_N Net-_R77-Pad2_ NC_78 /PHYs/LED_1_5 /PHYs/LED_0_5 /PHYs/A1V8_5 /GND DP83867
L23 /PHYs/A2V5_5 /PHYs/2V5 600R
L25 /PHYs/A1V0_5 /PHYs/1V0 600R
L24 /PHYs/A1V8_5 /PHYs/1V8 600R
R76 /GND Net-_R76-Pad2_ 11K
R77 /PHYs/1V8 Net-_R77-Pad2_ 10k
C133 /PHYs/SGMII5_TX_C_P /PHYs/SGMII5_TX_P 0.1 uF
C134 /PHYs/SGMII5_TX_C_N /PHYs/SGMII5_TX_N 0.1 uF
C135 /PHYs/SGMII5_RX_C_P /SGMII5_RX_P 0.1 uF
C136 /PHYs/SGMII5_RX_C_N /SGMII5_RX_N 0.1 uF
C150 /PHYs/2V5 /GND 4.7 uF
C168 /PHYs/A2V5_5 /GND 4.7 uF
C188 /PHYs/A2V5_5 /GND 0.47 uF
C204 /PHYs/A2V5_5 /GND 0.47 uF
C151 /PHYs/1V8 /GND 4.7 uF
C169 /PHYs/A1V8_5 /GND 4.7 uF
C189 /PHYs/A1V8_5 /GND 0.47 uF
C205 /PHYs/A1V8_5 /GND 0.47 uF
C152 /PHYs/1V0 /GND 4.7 uF
C170 /PHYs/A1V0_5 /GND 4.7 uF
C190 /PHYs/A1V0_5 /GND 0.47 uF
C206 /PHYs/A1V0_5 /GND 0.47 uF
C218 /PHYs/A1V0_5 /GND 0.47 uF
C226 /PHYs/A1V0_5 /GND 0.47 uF
C149 /PHYs/1V8 /GND 0.47 uF
C162 /PHYs/1V8 /GND 0.47 uF
C178 /PHYs/1V8 /GND 0.47 uF
R85 /PHYs/RX_CTRL_5 /PHYs/1V8 5.76K
R100 /GND /PHYs/RX_CTRL_5 2.49K
R122 /PHYs/LED1_5_N Net-_Q7-PadD1_ 470
R140 /PHYs/LED0_5_N Net-_Q7-PadD2_ 470
R133 /PHYs/1V8 /PHYs/LED_0_5 10K
R134 /PHYs/LED_0_5 /GND 2.49K
L33 Net-_L33-Pad1_ /PHYs/ETH5_AM_N /PHYs/ETH5_AM_P Net-_L33-Pad4_ /PHYs/ETH5_BM_N /PHYs/ETH5_BM_P Net-_L33-Pad7_ /PHYs/ETH5_CM_P /PHYs/ETH5_CM_N Net-_L33-Pad10_ /PHYs/ETH5_DM_N /PHYs/ETH5_DM_P /PHYs/ETH5_D_N /PHYs/ETH5_D_P Net-_C182-Pad2_ /PHYs/ETH5_C_N /PHYs/ETH5_C_P Net-_C198-Pad2_ /PHYs/ETH5_B_N /PHYs/ETH5_B_P Net-_C214-Pad2_ /PHYs/ETH5_A_N /PHYs/ETH5_A_P Net-_C222-Pad2_ BOURNS_PT6120EL
C222 /GND Net-_C222-Pad2_ 0.1 uF
C214 /GND Net-_C214-Pad2_ 0.1 uF
C198 /GND Net-_C198-Pad2_ 0.1 uF
C182 /GND Net-_C182-Pad2_ 0.1 uF
R112 Net-_C230-Pad2_ Net-_L33-Pad1_ 75
R116 Net-_C230-Pad2_ Net-_L33-Pad4_ 75
R121 Net-_C230-Pad2_ Net-_L33-Pad7_ 75
R128 Net-_C230-Pad2_ Net-_L33-Pad10_ 75
C230 /PHYs/SHIELD Net-_C230-Pad2_ 10 nF 2 kV
R86 /PHYs/RX_D0_5 /PHYs/1V8 10K
R101 /GND /PHYs/RX_D0_5 2.49K
U14 /PHYs/ETH6_A_P /PHYs/ETH6_A_N /PHYs/A2V5_7 /PHYs/ETH6_B_P /PHYs/ETH6_B_N /PHYs/A1V0_7 /PHYs/ETH6_C_P /PHYs/ETH6_C_N /PHYs/A2V5_7 /PHYs/ETH6_D_P /PHYs/ETH6_D_N Net-_R78-Pad2_ /PHYs/A1V8_7 NC_79 /PHYs/CLK_25MHZ_6 /MGMT_MDC /MGMT_MDIO NC_80 /PHYs/1V8 /JTAG_TCK /PHYs/JTAG_TDO_6 /JTAG_TMS /PHYs/JTAG_TDO_5 /PHYs/A1V0_7 NC_81 NC_82 /PHYs/SGMII6_TX_C_P /PHYs/SGMII6_TX_C_N NC_83 /PHYs/1V8 /PHYs/A1V0_7 NC_84 /PHYs/RX_D0_6 NC_85 /PHYs/SGMII6_RX_C_P /PHYs/SGMII6_RX_C_N NC_86 /PHYs/RX_CTRL_6 NC_87 NC_88 /PHYs/1V8 /PHYs/A1V0_7 /PHY_RST_N Net-_R79-Pad2_ NC_89 /PHYs/LED_1_6 /PHYs/LED_0_6 /PHYs/A1V8_7 /GND DP83867
R78 /GND Net-_R78-Pad2_ 11K
R79 /PHYs/1V8 Net-_R79-Pad2_ 10k
C137 /PHYs/SGMII6_TX_C_P /PHYs/SGMII6_TX_P 0.1 uF
C138 /PHYs/SGMII6_TX_C_N /PHYs/SGMII6_TX_N 0.1 uF
C139 /PHYs/SGMII6_RX_C_P /SGMII6_RX_P 0.1 uF
C140 /PHYs/SGMII6_RX_C_N /SGMII6_RX_N 0.1 uF
C171 /PHYs/A2V5_7 /GND 4.7 uF
C191 /PHYs/A2V5_7 /GND 0.47 uF
C207 /PHYs/A2V5_7 /GND 0.47 uF
C172 /PHYs/A1V8_7 /GND 4.7 uF
C192 /PHYs/A1V8_7 /GND 0.47 uF
C208 /PHYs/A1V8_7 /GND 0.47 uF
C173 /PHYs/A1V0_7 /GND 4.7 uF
C193 /PHYs/A1V0_7 /GND 0.47 uF
C209 /PHYs/A1V0_7 /GND 0.47 uF
C219 /PHYs/A1V0_7 /GND 0.47 uF
C227 /PHYs/A1V0_7 /GND 0.47 uF
C153 /PHYs/1V8 /GND 0.47 uF
C163 /PHYs/1V8 /GND 0.47 uF
C179 /PHYs/1V8 /GND 0.47 uF
R89 /PHYs/RX_CTRL_6 /PHYs/1V8 5.76K
R104 /GND /PHYs/RX_CTRL_6 2.49K
Q6 Net-_Q6-PadD1_ Net-_Q6-PadD2_ /PHYs/LED_1_6 /PHYs/LED_0_6 /GND /GND SSM6N58NU
R124 /PHYs/LED1_6_N Net-_Q6-PadD1_ 470
Q8 Net-_Q8-PadD1_ Net-_Q8-PadD2_ /PHYs/LED_1_7 /PHYs/LED_0_7 /GND /GND SSM6N58NU
R141 /PHYs/LED0_6_N Net-_Q6-PadD2_ 470
R135 /PHYs/1V8 /PHYs/LED_0_6 10K
R136 /PHYs/LED_0_6 /GND 2.49K
L34 Net-_L34-Pad1_ /PHYs/ETH6_AM_P /PHYs/ETH6_AM_N Net-_L34-Pad4_ /PHYs/ETH6_BM_P /PHYs/ETH6_BM_N Net-_L34-Pad7_ /PHYs/ETH6_CM_P /PHYs/ETH6_CM_N Net-_L34-Pad10_ /PHYs/ETH6_DM_N /PHYs/ETH6_DM_P /PHYs/ETH6_D_N /PHYs/ETH6_D_P Net-_C183-Pad2_ /PHYs/ETH6_C_N /PHYs/ETH6_C_P Net-_C199-Pad2_ /PHYs/ETH6_B_N /PHYs/ETH6_B_P Net-_C215-Pad2_ /PHYs/ETH6_A_N /PHYs/ETH6_A_P Net-_C223-Pad2_ BOURNS_PT6120EL
C223 /GND Net-_C223-Pad2_ 0.1 uF
C215 /GND Net-_C215-Pad2_ 0.1 uF
C199 /GND Net-_C199-Pad2_ 0.1 uF
C183 /GND Net-_C183-Pad2_ 0.1 uF
R113 Net-_C231-Pad2_ Net-_L34-Pad1_ 75
R117 Net-_C231-Pad2_ Net-_L34-Pad4_ 75
R123 Net-_C231-Pad2_ Net-_L34-Pad7_ 75
R129 Net-_C231-Pad2_ Net-_L34-Pad10_ 75
C231 /PHYs/SHIELD Net-_C231-Pad2_ 10 nF 2 kV
R90 /PHYs/RX_D0_6 /PHYs/1V8 5.76k
R105 /GND /PHYs/RX_D0_6 2.49K
U15 /PHYs/ETH7_A_P /PHYs/ETH7_A_N /PHYs/A2V5_7 /PHYs/ETH7_B_P /PHYs/ETH7_B_N /PHYs/A1V0_7 /PHYs/ETH7_C_P /PHYs/ETH7_C_N /PHYs/A2V5_7 /PHYs/ETH7_D_P /PHYs/ETH7_D_N Net-_R80-Pad2_ /PHYs/A1V8_7 NC_90 /PHYs/CLK_25MHZ_7 /MGMT_MDC /MGMT_MDIO NC_91 /PHYs/1V8 /JTAG_TCK /JTAG_TDO /JTAG_TMS /PHYs/JTAG_TDO_6 /PHYs/A1V0_7 NC_92 NC_93 /PHYs/SGMII7_TX_C_P /PHYs/SGMII7_TX_C_N NC_94 /PHYs/1V8 /PHYs/A1V0_7 NC_95 /PHYs/RX_D0_7 NC_96 /PHYs/SGMII7_RX_C_P /PHYs/SGMII7_RX_C_N NC_97 /PHYs/RX_CTRL_7 NC_98 NC_99 /PHYs/1V8 /PHYs/A1V0_7 /PHY_RST_N Net-_R81-Pad2_ NC_100 /PHYs/LED_1_7 /PHYs/LED_0_7 /PHYs/A1V8_7 /GND DP83867
L29 /PHYs/A2V5_7 /PHYs/2V5 600R
L31 /PHYs/A1V0_7 /PHYs/1V0 600R
L30 /PHYs/A1V8_7 /PHYs/1V8 600R
R80 /GND Net-_R80-Pad2_ 11K
R81 /PHYs/1V8 Net-_R81-Pad2_ 10k
C141 /PHYs/SGMII7_TX_C_P /PHYs/SGMII7_TX_P 0.1 uF
C142 /PHYs/SGMII7_TX_C_N /PHYs/SGMII7_TX_N 0.1 uF
C143 /PHYs/SGMII7_RX_C_P /SGMII7_RX_P 0.1 uF
C144 /PHYs/SGMII7_RX_C_N /SGMII7_RX_N 0.1 uF
C158 /PHYs/2V5 /GND 4.7 uF
C174 /PHYs/A2V5_7 /GND 4.7 uF
C194 /PHYs/A2V5_7 /GND 0.47 uF
C210 /PHYs/A2V5_7 /GND 0.47 uF
C159 /PHYs/1V8 /GND 4.7 uF
C175 /PHYs/A1V8_7 /GND 4.7 uF
C195 /PHYs/A1V8_7 /GND 0.47 uF
C211 /PHYs/A1V8_7 /GND 0.47 uF
C160 /PHYs/1V0 /GND 4.7 uF
C176 /PHYs/A1V0_7 /GND 4.7 uF
C196 /PHYs/A1V0_7 /GND 0.47 uF
C212 /PHYs/A1V0_7 /GND 0.47 uF
C220 /PHYs/A1V0_7 /GND 0.47 uF
C228 /PHYs/A1V0_7 /GND 0.47 uF
C157 /PHYs/1V8 /GND 0.47 uF
C164 /PHYs/1V8 /GND 0.47 uF
C180 /PHYs/1V8 /GND 0.47 uF
R93 /PHYs/RX_CTRL_7 /PHYs/1V8 5.76K
R108 /GND /PHYs/RX_CTRL_7 2.49K
R126 /PHYs/LED1_7_N Net-_Q8-PadD1_ 470
R142 /PHYs/LED0_7_N Net-_Q8-PadD2_ 470
R137 /PHYs/1V8 /PHYs/LED_0_7 10K
R138 /PHYs/LED_0_7 /GND 2.49K
L35 Net-_L35-Pad1_ /PHYs/ETH7_AM_N /PHYs/ETH7_AM_P Net-_L35-Pad4_ /PHYs/ETH7_BM_P /PHYs/ETH7_BM_N Net-_L35-Pad7_ /PHYs/ETH7_CM_N /PHYs/ETH7_CM_P Net-_L35-Pad10_ /PHYs/ETH7_DM_N /PHYs/ETH7_DM_P /PHYs/ETH7_D_N /PHYs/ETH7_D_P Net-_C184-Pad2_ /PHYs/ETH7_C_N /PHYs/ETH7_C_P Net-_C200-Pad2_ /PHYs/ETH7_B_N /PHYs/ETH7_B_P Net-_C216-Pad2_ /PHYs/ETH7_A_N /PHYs/ETH7_A_P Net-_C224-Pad2_ BOURNS_PT6120EL
C224 /GND Net-_C224-Pad2_ 0.1 uF
C216 /GND Net-_C216-Pad2_ 0.1 uF
C200 /GND Net-_C200-Pad2_ 0.1 uF
C184 /GND Net-_C184-Pad2_ 0.1 uF
R114 Net-_C232-Pad2_ Net-_L35-Pad1_ 75
R118 Net-_C232-Pad2_ Net-_L35-Pad4_ 75
R125 Net-_C232-Pad2_ Net-_L35-Pad7_ 75
R130 Net-_C232-Pad2_ Net-_L35-Pad10_ 75
C232 /PHYs/SHIELD Net-_C232-Pad2_ 10 nF 2 kV
R94 /PHYs/RX_D0_7 /PHYs/1V8 2.49K
R83 /PHYs/SGMII4_RX_C_P /PHYs/1V8 10k
R84 /PHYs/SGMII4_RX_C_N /PHYs/1V8 10k
R98 /GND /PHYs/SGMII4_RX_C_P 2.49K
R99 /GND /PHYs/SGMII4_RX_C_N 2.49K
R95 /PHYs/SGMII7_RX_C_P /PHYs/1V8 10k
R96 /PHYs/SGMII7_RX_C_N /PHYs/1V8 10k
R109 /GND /PHYs/SGMII7_RX_C_P 2.49K
R110 /GND /PHYs/SGMII7_RX_C_N 2.49K
R91 /PHYs/SGMII6_RX_C_P /PHYs/1V8 10k
R92 /PHYs/SGMII6_RX_C_N /PHYs/1V8 10k
R106 /GND /PHYs/SGMII6_RX_C_P 2.49K
R107 /GND /PHYs/SGMII6_RX_C_N 2.49K
R87 /PHYs/SGMII5_RX_C_P /PHYs/1V8 10k
R88 /PHYs/SGMII5_RX_C_N /PHYs/1V8 10k
R102 /GND /PHYs/SGMII5_RX_C_P 2.49K
R103 /GND /PHYs/SGMII5_RX_C_N 2.49K
U16 /PHYs/1V8 /GND Net-_R143-Pad2_ /PHYs/1V8 DSC6101CI2A-025.0000
C233 /PHYs/1V8 /GND 0.47 uF
R143 /PHYs/CLK_25MHZ Net-_R143-Pad2_ 33
U17 Net-_R144-Pad2_ /GND /PHYs/1V8 Net-_R145-Pad2_ /GND Net-_R146-Pad2_ Net-_R147-Pad2_ /PHYs/1V8 Net-_R148-Pad2_ /GND Net-_R149-Pad2_ /PHYs/1V8 Net-_R150-Pad2_ Net-_R151-Pad2_ /PHYs/CLK_25MHZ /PHYs/1V8 5PB1108CMG
C235 /PHYs/1V8 /GND 0.47 uF
C234 /PHYs/1V8 /GND 4.7 uF
C236 /PHYs/1V8 /GND 0.47 uF
C237 /PHYs/1V8 /GND 0.47 uF
R144 /PHYs/CLK_25MHZ_0 Net-_R144-Pad2_ 33
R145 /PHYs/CLK_25MHZ_1 Net-_R145-Pad2_ 33
R146 /PHYs/CLK_25MHZ_2 Net-_R146-Pad2_ 33
R147 /PHYs/CLK_25MHZ_3 Net-_R147-Pad2_ 33
R148 /PHYs/CLK_25MHZ_4 Net-_R148-Pad2_ 33
R149 /PHYs/CLK_25MHZ_5 Net-_R149-Pad2_ 33
R150 /PHYs/CLK_25MHZ_6 Net-_R150-Pad2_ 33
R151 /PHYs/CLK_25MHZ_7 Net-_R151-Pad2_ 33
C238 /PHYs/SHIELD /GND TBD
C239 /PHYs/SHIELD /GND TBD
R157 /PHYs/SHIELD /GND TBD
R158 /PHYs/SHIELD /GND TBD
.end
