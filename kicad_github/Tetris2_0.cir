.title KiCad schematic
ATMEGA328 PC6 Net-_ATMEGA328-Pad2_ Net-_ATMEGA328-Pad3_ Net-_ATMEGA328-Pad4_ Net-_ATMEGA328-Pad5_ Net-_ATMEGA328-Pad6_ VCC GND Net-_16MHz1-Pad1_ Net-_16MHz1-Pad2_ Net-_ATMEGA328-Pad11_ PD6 NC_01 PB0 PB1 PB2 PB3 PB4 PB5 NC_02 NC_03 GND Net-_ATMEGA328-Pad23_ Net-_ATMEGA328-Pad24_ Net-_ATMEGA328-Pad25_ Net-_ATMEGA328-Pad26_ Net-_ATMEGA328-Pad27_ Net-_ATMEGA328-Pad28_ ATMEGA328P-PU
POWER1 VCC power NC_04 SW_SPDT
5_IN1 power GND CONN_01X02
16MHz1 Net-_16MHz1-Pad1_ Net-_16MHz1-Pad2_ Crystal
C1 GND Net-_16MHz1-Pad1_ C
C2 GND Net-_16MHz1-Pad2_ C
SEG1 PC4 PC3 Net-_Q1-Pad2_ PC2 PD1 PC1 PC0 Net-_Q1-Pad2_ PC5 PD0 7SEGMENTS
Q1 PD2 Net-_Q1-Pad2_ GND Q_NPN_BCE
SEG3 PC4 PC3 Net-_Q3-Pad2_ PC2 PD1 PC1 PC0 Net-_Q3-Pad2_ PC5 PD0 7SEGMENTS
Q3 PD4 Net-_Q3-Pad2_ GND Q_NPN_BCE
SEG2 PC4 PC3 Net-_Q2-Pad2_ PC2 PD1 PC1 PC0 Net-_Q2-Pad2_ PC5 PD0 7SEGMENTS
Q2 PD3 Net-_Q2-Pad2_ GND Q_NPN_BCE
SEG4 PC4 PC3 Net-_Q4-Pad2_ PC2 PD1 PC1 PC0 Net-_Q4-Pad2_ PC5 PD0 7SEGMENTS
Q4 PD5 Net-_Q4-Pad2_ GND Q_NPN_BCE
LED1 PD6 CONN_01X01
SW1 PB0 GND SW_Push
SW2 PB1 GND SW_Push
SW3 PB2 GND SW_Push
SW4 PB3 GND SW_Push
SW5 PB4 GND SW_Push
SW6 PB5 GND SW_Push
ICSP1 PB3 power NC_05 GND PC6 GND PB5 GND PB4 GND CONN_02X05
R1 PC0 Net-_ATMEGA328-Pad23_ R
R2 PC1 Net-_ATMEGA328-Pad24_ R
R3 PC2 Net-_ATMEGA328-Pad25_ R
R4 PC3 Net-_ATMEGA328-Pad26_ R
R5 PC4 Net-_ATMEGA328-Pad27_ R
R6 PC5 Net-_ATMEGA328-Pad28_ R
R7 PD0 Net-_ATMEGA328-Pad2_ R
R8 PD1 Net-_ATMEGA328-Pad3_ R
R9 PD2 Net-_ATMEGA328-Pad4_ R
R10 PD3 Net-_ATMEGA328-Pad5_ R
R11 PD4 Net-_ATMEGA328-Pad6_ R
R12 PD5 Net-_ATMEGA328-Pad11_ R
R13 power PC6 R
.end
