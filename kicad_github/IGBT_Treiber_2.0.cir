.title KiCad schematic
R15 High_IGBT_Gate Net-_R11-Pad2_ R
R16 HV_VCC High_IGBT_Gate R
R4 Net-_R22-Pad2_ Low_IGBT_Gate R
R1 Low_IGBT_GND Low_IGBT_Gate R
C4 NC_01 Net-_C4-Pad2_ 1 uF
P1 High_IGBT_Gate CONN_01X01
P2 HV_VCC CONN_01X01
R2 Net-_C1-Pad2_ L1_H 51
R3 Net-_C2-Pad2_ L1_L 51
R14 High_IGBT_Gate Net-_R11-Pad2_ R
R13 High_IGBT_Gate Net-_R11-Pad2_ R
R12 High_IGBT_Gate Net-_R11-Pad2_ R
R11 High_IGBT_Gate Net-_R11-Pad2_ R
R5 Net-_R22-Pad2_ Low_IGBT_Gate R
R6 Net-_R22-Pad2_ Low_IGBT_Gate R
R7 Net-_R22-Pad2_ Low_IGBT_Gate R
R8 Net-_R22-Pad2_ Low_IGBT_Gate R
C2 GND Net-_C2-Pad2_ 220pF
C1 GND Net-_C1-Pad2_ 220pF
C3 HV_GND VDD 4,7 uF
D1 Net-_C4-Pad2_ Net-_D1-Pad2_ D
R10 Net-_D1-Pad2_ VDD R
R9 HV_VCC VDD 2,2 Ohm
P3 Low_IGBT_GND CONN_01X01
P4 Low_IGBT_Gate CONN_01X01
R24 Net-_C4-Pad2_ Net-_R24-Pad2_ 0 Ohm
R25 NC_02 Net-_R25-Pad2_ 0 Ohm
R26 NC_03 Net-_R26-Pad2_ 0 Ohm
R17 Net-_R17-Pad1_ Net-_C1-Pad2_ 0 Ohm
R18 Net-_R18-Pad1_ Net-_C2-Pad2_ 0 Ohm
R19 Net-_R19-Pad1_ HV_GND 0 Ohm
R20 Net-_R20-Pad1_ EN/NC 0 Ohm
R21 Net-_R21-Pad1_ Low_IGBT_GND 0 Ohm
R22 Net-_R22-Pad1_ Net-_R22-Pad2_ 0 Ohm
R23 Net-_R23-Pad1_ VDD 0 Ohm
P5 LV_AC2 LV_AC2 LV_AC1 LV_AC1 NC_04 EN/NC L1_L L1_H CONN_01X08
T1 NC_05 NC_06 Net-_D3-Pad2_ HV_GND Net-_D2-Pad2_ Transformer_1P_SS
D3 HV_VCC Net-_D3-Pad2_ D
D2 HV_VCC Net-_D2-Pad2_ D
D4 HV_VCC HV_GND D_Zener
U1 Net-_R17-Pad1_ Net-_R18-Pad1_ Net-_R19-Pad1_ Net-_R20-Pad1_ Net-_R21-Pad1_ Net-_R22-Pad1_ Net-_R23-Pad1_ NC_07 NC_08 NC_09 Net-_R26-Pad2_ Net-_R25-Pad2_ Net-_R24-Pad2_ NC_10 UCC27714
C6 HV_GND HV_VCC 100nF
U2 /ACS1_Con_X31/AC1 /ACS1_Con_X31/AC2 /ACS1_Con_X31/AC1 /ACS1_Con_X31/AC2 /ACS1_Con_X31/AC1 /ACS1_Con_X31/AC2 /ACS1_Con_X31/AC1 /ACS1_Con_X31/AC2 /ACS1_Con_X31/AC1 /ACS1_Con_X31/AC2 GND NC_11 NC_12 GND NC_13 NC_14 GND /ACS1_Con_X31/-15VDC /ACS1_Con_X31/-15VDC GND /ACS1_Con_X31/+3,3VDC /ACS1_Con_X31/+3,3VDC /ACS1_Con_X31/+3,3VDC /ACS1_Con_X31/+3,3VDC GND GND NC_15 GND NC_16 NC_17 GND NC_18 NC_19 GND NC_20 NC_21 GND NC_22 NC_23 GND NC_24 NC_25 GND NC_26 /ACS1_Con_X31/HS2 GND /ACS1_Con_X31/TS1 NC_27 GND NC_28 Net-_U2-Pad51_ GND NC_29 NC_30 GND NC_31 NC_32 GND NC_33 NC_34 GND NC_35 NC_36 GND GND GND GND GND HARFLEX-64P
R27 Net-_C5-Pad2_ /ACS1_Con_X31/AC1 10 Ohm
R28 Net-_C5-Pad2_ /ACS1_Con_X31/AC1 10 Ohm
C5 /ACS1_Con_X31/AC2 Net-_C5-Pad2_ C
.end
