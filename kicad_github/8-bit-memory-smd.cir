.title KiCad schematic
Q2 GND /I0 Net-_Q2-Pad3_ 2N7000
Q3 GND Net-_Q2-Pad3_ Net-_Q3-Pad3_ 2N7000
Q4 GND /notW Net-_Q3-Pad3_ 2N7000
Q7 GND /I0 Net-_Q7-Pad3_ 2N7000
Q8 GND /notW Net-_Q7-Pad3_ 2N7000
Q9 GND Net-_Q7-Pad3_ /O0 2N7000
Q10 GND Net-_Q10-Pad2_ /O0 2N7000
Q5 GND Net-_Q3-Pad3_ Net-_Q10-Pad2_ 2N7000
Q6 GND /O0 Net-_Q10-Pad2_ 2N7000
R3 VCC Net-_Q2-Pad3_ R
R4 VCC Net-_Q3-Pad3_ R
R5 VCC Net-_Q10-Pad2_ R
R6 VCC Net-_Q7-Pad3_ R
R7 VCC /O0 R
J3 GND VCC J2-2_pole_connector
J2 /I0 /I1 /I2 /I3 /I4 /I5 /I6 /I7 J8-8_bit_bus_connector
J1 /W J1-1_bit_bus
Q1 GND /W /notW 2N7000
R1 VCC /notW R
J4 /O0 /O1 /O2 /O3 /O4 /O5 /O6 /O7 J8-8_bit_bus_connector
Q11 GND /I1 Net-_Q11-Pad3_ 2N7000
Q12 GND Net-_Q11-Pad3_ Net-_Q12-Pad3_ 2N7000
Q13 GND /notW Net-_Q12-Pad3_ 2N7000
Q16 GND /I1 Net-_Q16-Pad3_ 2N7000
Q17 GND /notW Net-_Q16-Pad3_ 2N7000
Q18 GND Net-_Q16-Pad3_ /O1 2N7000
Q19 GND Net-_Q14-Pad3_ /O1 2N7000
Q14 GND Net-_Q12-Pad3_ Net-_Q14-Pad3_ 2N7000
Q15 GND /O1 Net-_Q14-Pad3_ 2N7000
R9 VCC Net-_Q11-Pad3_ R
R10 VCC Net-_Q12-Pad3_ R
R11 VCC Net-_Q14-Pad3_ R
R12 VCC Net-_Q16-Pad3_ R
R13 VCC /O1 R
Q20 GND /I2 Net-_Q20-Pad3_ 2N7000
Q21 GND Net-_Q20-Pad3_ Net-_Q21-Pad3_ 2N7000
Q22 GND /notW Net-_Q21-Pad3_ 2N7000
Q25 GND /I2 Net-_Q25-Pad3_ 2N7000
Q26 GND /notW Net-_Q25-Pad3_ 2N7000
Q27 GND Net-_Q25-Pad3_ /O2 2N7000
Q28 GND Net-_Q23-Pad3_ /O2 2N7000
Q23 GND Net-_Q21-Pad3_ Net-_Q23-Pad3_ 2N7000
Q24 GND /O2 Net-_Q23-Pad3_ 2N7000
R15 VCC Net-_Q20-Pad3_ R
R16 VCC Net-_Q21-Pad3_ R
R17 VCC Net-_Q23-Pad3_ R
R18 VCC Net-_Q25-Pad3_ R
R19 VCC /O2 R
Q29 GND /I3 Net-_Q29-Pad3_ 2N7000
Q30 GND Net-_Q29-Pad3_ Net-_Q30-Pad3_ 2N7000
Q31 GND /notW Net-_Q30-Pad3_ 2N7000
Q34 GND /I3 Net-_Q34-Pad3_ 2N7000
Q35 GND /notW Net-_Q34-Pad3_ 2N7000
Q36 GND Net-_Q34-Pad3_ /O3 2N7000
Q37 GND Net-_Q32-Pad3_ /O3 2N7000
Q32 GND Net-_Q30-Pad3_ Net-_Q32-Pad3_ 2N7000
Q33 GND /O3 Net-_Q32-Pad3_ 2N7000
R21 VCC Net-_Q29-Pad3_ R
R22 VCC Net-_Q30-Pad3_ R
R23 VCC Net-_Q32-Pad3_ R
R24 VCC Net-_Q34-Pad3_ R
R25 VCC /O3 R
Q38 GND /I4 Net-_Q38-Pad3_ 2N7000
Q39 GND Net-_Q38-Pad3_ Net-_Q39-Pad3_ 2N7000
Q40 GND /notW Net-_Q39-Pad3_ 2N7000
Q43 GND /I4 Net-_Q43-Pad3_ 2N7000
Q44 GND /notW Net-_Q43-Pad3_ 2N7000
Q45 GND Net-_Q43-Pad3_ /O4 2N7000
Q46 GND Net-_Q41-Pad3_ /O4 2N7000
Q41 GND Net-_Q39-Pad3_ Net-_Q41-Pad3_ 2N7000
Q42 GND /O4 Net-_Q41-Pad3_ 2N7000
R27 VCC Net-_Q38-Pad3_ R
R28 VCC Net-_Q39-Pad3_ R
R29 VCC Net-_Q41-Pad3_ R
R30 VCC Net-_Q43-Pad3_ R
R31 VCC /O4 R
Q47 GND /I5 Net-_Q47-Pad3_ 2N7000
Q48 GND Net-_Q47-Pad3_ Net-_Q48-Pad3_ 2N7000
Q49 GND /notW Net-_Q48-Pad3_ 2N7000
Q52 GND /I5 Net-_Q52-Pad3_ 2N7000
Q53 GND /notW Net-_Q52-Pad3_ 2N7000
Q54 GND Net-_Q52-Pad3_ /O5 2N7000
Q55 GND Net-_Q50-Pad3_ /O5 2N7000
Q50 GND Net-_Q48-Pad3_ Net-_Q50-Pad3_ 2N7000
Q51 GND /O5 Net-_Q50-Pad3_ 2N7000
R33 VCC Net-_Q47-Pad3_ R
R34 VCC Net-_Q48-Pad3_ R
R35 VCC Net-_Q50-Pad3_ R
R36 VCC Net-_Q52-Pad3_ R
R37 VCC /O5 R
Q56 GND /I6 Net-_Q56-Pad3_ 2N7000
Q57 GND Net-_Q56-Pad3_ Net-_Q57-Pad3_ 2N7000
Q58 GND /notW Net-_Q57-Pad3_ 2N7000
Q61 GND /I6 Net-_Q61-Pad3_ 2N7000
Q62 GND /notW Net-_Q61-Pad3_ 2N7000
Q63 GND Net-_Q61-Pad3_ /O6 2N7000
Q64 GND Net-_Q59-Pad3_ /O6 2N7000
Q59 GND Net-_Q57-Pad3_ Net-_Q59-Pad3_ 2N7000
Q60 GND /O6 Net-_Q59-Pad3_ 2N7000
R39 VCC Net-_Q56-Pad3_ R
R40 VCC Net-_Q57-Pad3_ R
R41 VCC Net-_Q59-Pad3_ R
R42 VCC Net-_Q61-Pad3_ R
R43 VCC /O6 R
Q65 GND /I7 Net-_Q65-Pad3_ 2N7000
Q66 GND Net-_Q65-Pad3_ Net-_Q66-Pad3_ 2N7000
Q67 GND /notW Net-_Q66-Pad3_ 2N7000
Q70 GND /I7 Net-_Q70-Pad3_ 2N7000
Q71 GND /notW Net-_Q70-Pad3_ 2N7000
Q72 GND Net-_Q70-Pad3_ /O7 2N7000
Q73 GND Net-_Q68-Pad3_ /O7 2N7000
Q68 GND Net-_Q66-Pad3_ Net-_Q68-Pad3_ 2N7000
Q69 GND /O7 Net-_Q68-Pad3_ 2N7000
R45 VCC Net-_Q65-Pad3_ R
R46 VCC Net-_Q66-Pad3_ R
R47 VCC Net-_Q68-Pad3_ R
R48 VCC Net-_Q70-Pad3_ R
R49 VCC /O7 R
R2 GND /I0 R
R8 GND /I1 R
R14 GND /I2 R
R20 GND /I3 R
R26 GND /I4 R
R32 GND /I5 R
R38 GND /I6 R
R44 GND /I7 R
.end
