.title KiCad schematic
Q1 Net-_D1-Pad2_ Net-_F1-Pad1_ +24V Q_PMOS_GDS
R1 Net-_D1-Pad2_ GND R
D1 +24V Net-_D1-Pad2_ D_Zener
U1 +5V +5V +5V GND GND +24V +24V +5V +5V +5V GND GND +24V +24V +5V +5V +5V GND GND +24V +24V +5V +5V +5V GND GND GND GND GND GND GND Net-_U1-Pad5F_ Net-_U1-Pad5F_ GND GND GND GND GND GND GND NC_01 GND GND GND GND GND NC_02 Net-_R3-Pad2_ Net-_R2-Pad2_ LTM8022or8023
R2 GND Net-_R2-Pad2_ R
R3 GND Net-_R3-Pad2_ R
C4 +5V GND C
C3 +5V GND CP
C2 +24V GND CP
C1 +24V GND C
U2 SD_CD SD_CD SD_CD GND GND +24V +24V SD_CD SD_CD SD_CD GND GND +24V +24V SD_CD SD_CD SD_CD GND GND +24V +24V SD_CD SD_CD SD_CD GND GND GND GND GND GND GND Net-_U2-Pad5F_ Net-_U2-Pad5F_ GND GND GND GND GND GND GND NC_03 GND GND GND GND GND NC_04 Net-_R5-Pad2_ Net-_R4-Pad2_ LTM8022or8023
R4 GND Net-_R4-Pad2_ R
R5 GND Net-_R5-Pad2_ R
C8 SD_CD GND C
C7 SD_CD GND CP
C6 +24V GND CP
C5 +24V GND C
F1 Net-_F1-Pad1_ +BATT Fuse
D2 +24V GND D_Zener
D3 +24V GND D_Zener
D4 +5V GND D_Zener
D5 +5V GND D_Zener
D6 SD_CD GND D_Zener
D7 SD_CD GND D_Zener
IC2 Net-_C15-Pad2_ Net-_C13-Pad2_ NC_05 NC_06 GND SD_CD NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 Net-_IC2-Pad13_ GND SD_CD Net-_IC2-Pad16_ NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 GND SD_CD NC_21 NC_22 NC_23 NC_24 GND SD_CD FLASH_IO0 FLASH_IO1 FLASH_IO2 FLASH_IO3 SD_CD GND FLASH_SCK FLASH_CS NC_25 NC_26 NC_27 NC_28 GND SD_CD NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 GND SD_CD NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 GND SD_CD NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 GND SD_CD NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 GND SD_CD NC_66 NC_67 D- D+ GND SD_CD NC_68 NC_69 NC_70 NC_71 SD_MOSI SD_SCK SD_CS SD_MISO GND SD_CD RGBLED Net-_IC2-Pad109_ Net-_IC2-Pad110_ Net-_IC2-Pad111_ Net-_IC2-Pad112_ Net-_IC2-Pad113_ Net-_C29-Pad1_ Net-_C11-Pad1_ GND Net-_IC2-Pad117_ SD_CD NC_72 SWDIO SWO SD_CD TXLED RXLED NC_73 D13 NC_74 NC_75 ATSAMD51P20A-AF
L1 Net-_C11-Pad1_ Net-_IC2-Pad117_ L
C14 Net-_C11-Pad1_ GND C
C12 Net-_C11-Pad1_ GND CP
C11 Net-_C11-Pad1_ GND CP
C21 SD_CD GND C
C22 SD_CD GND C
C23 SD_CD GND C
C24 SD_CD GND C
C25 SD_CD GND C
C16 SD_CD GND C
C17 SD_CD GND C
C18 SD_CD GND C
C19 SD_CD GND C
C20 SD_CD GND C
C26 SD_CD GND C
C27 SD_CD GND C
C28 SD_CD GND C
C29 Net-_C29-Pad1_ GND C
R15 SD_CD Net-_C29-Pad1_ R
Y1 Net-_C13-Pad2_ Net-_C15-Pad2_ Crystal
C13 GND Net-_C13-Pad2_ C
C15 GND Net-_C15-Pad2_ C
R11 GND Net-_IC2-Pad112_ R
R12 GND Net-_IC2-Pad111_ R
R13 GND Net-_IC2-Pad110_ R
R14 GND Net-_IC2-Pad109_ R
R10 GND Net-_IC2-Pad13_ R
R9 GND Net-_IC2-Pad16_ R
D13 Net-_D13-Pad1_ SD_CD LED
R16 Net-_D13-Pad1_ RXLED R
D14 Net-_D14-Pad1_ SD_CD LED
R17 Net-_D14-Pad1_ TXLED R
D15 Net-_D15-Pad1_ SD_CD LED
R18 Net-_D15-Pad1_ GND R
D16 Net-_D16-Pad1_ D13 LED
R19 Net-_D16-Pad1_ GND R
J2 SD_CD SWDIO GND SWDCLK GND SWO NC_76 NC_77 NC_78 NC_79 Conn_ARM_JTAG_SWD_10
R6 SWDCLK SD_CD R
IC1 FLASH_CS FLASH_IO1 FLASH_IO2 GND FLASH_IO0 FLASH_SCK FLASH_IO3 Net-_C10-Pad1_ W25Q64JVSSIM_TR
C10 Net-_C10-Pad1_ GND C
J1 NC_80 SD_CS SD_MOSI SD_CD SD_SCK GND SD_MISO NC_81 GND GND GND SD_CD GND DM3CS-SF
C9 SD_CD GND C
D9 SD_CD Net-_D10-Pad4_ GND RGBLED WS2812B
D10 SD_CD Net-_D10-Pad2_ GND Net-_D10-Pad4_ WS2812B
D11 SD_CD Net-_D11-Pad2_ GND Net-_D10-Pad2_ WS2812B
D12 SD_CD NC_82 GND Net-_D11-Pad2_ WS2812B
D8 GND D+ D- SD_CD PRTR5V0U2X
J3 NC_83 D+ D- GND 5787834-1
R7 SD_CD Net-_IC2-Pad113_ R
R8 Net-_IC2-Pad113_ GND R
D17 GND Net-_C30-Pad1_ Net-_C31-Pad2_ SD_CD PRTR5V0U2X
J4 NC_84 Net-_C30-Pad1_ Net-_C31-Pad2_ GND 5787834-1
R21 Net-_C31-Pad2_ NC_85 R
R20 Net-_C30-Pad1_ NC_86 R
C30 Net-_C30-Pad1_ GND C
C31 GND Net-_C31-Pad2_ C
J5 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 JD2-0001NL
IC3 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 NC_111 NC_112 NC_113 NC_114 NC_115 NC_116 NC_117 NC_118 NC_119 NC_120 NC_121 NC_122 NC_123 NC_124 NC_125 NC_126 NC_127 NC_128 NC_129 NC_130 NC_131 NC_132 NC_133 NC_134 NC_135 NC_136 NC_137 NC_138 NC_139 NC_140 NC_141 NC_142 NC_143 NC_144 NC_145 NC_146 W5500
.end
