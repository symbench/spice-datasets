.title KiCad schematic
J28 -12V -12V GND GND GND GND GND GND +12V +12V Net-_J27-Pad2_ Net-_J27-Pad2_ NC_01 NC_02 NC_03 NC_04 Conn_02x08_Odd_Even
J27 +5V Net-_J27-Pad2_ Conn_01x02
R5 +3V3 Net-_R5-Pad2_ 4.7k
R6 +3V3 Net-_R6-Pad2_ 4.7k
C41 +5V GND 0.1u
C35 +3V3 GND 0.1u
C38 +5V GND 0.1u
C36 +5V GND 0.1u
R7 +3V3 Net-_R7-Pad2_ 4.7k
C44 GND Net-_C44-Pad2_ 1u
C43 GND Net-_C43-Pad2_ 1u
C40 +5V GND 0.1u
U6 +5V GND GND GND GND Net-_R5-Pad2_ Net-_R6-Pad2_ /ADC_RANGE /ADC_CONVST /ADC_CONVST /ADC_RESET /ADC_SCK /ADC_CS /ADC_BUSY NC_05 GND GND GND GND GND GND GND +3V3 /ADC_MISO GND GND GND GND GND GND GND GND GND Net-_R7-Pad2_ GND Net-_C44-Pad2_ +5V +5V Net-_C43-Pad2_ GND GND NC_06 GND Net-_C42-Pad2_ Net-_C42-Pad2_ GND GND +5V /VIN8 /VGND8 /VIN7 /VGND7 /VIN6 /VGND6 /VIN5 /VGND5 /VIN4 /VGND4 /VIN3 /VGND3 /VIN2 /VGND2 /VIN1 /VGND1 AD7606BSTZ
C28 GND +5V 0.1u
C27 GND +5V 10u
C30 /DAC_REF2V5 GND 0.1u
C29 /DAC_REF2V5 GND 10u
U7 NC_07 Net-_D1-Pad1_ /MIDI_RX_PIN4 NC_08 GND /MIDI_RX NC_09 +3V3 6N138
R37 Net-_D1-Pad1_ /MIDI_RX_PIN2 220
D1 Net-_D1-Pad1_ /MIDI_RX_PIN4 D
R38 /MIDI_TX_PIN2 +3V3 220
C39 /DAC_REF2V5 GND 0.1u
C37 /DAC_REF2V5 GND 10u
C42 GND Net-_C42-Pad2_ 10u
U5 GND /DAC_REF2V5 +5V MCP1700-2502E
C33 GND -12V 10u
C32 GND -12V 0.1u
C24 +3V3 GND 0.1u
C23 +12V GND 0.1u
C19 +12V GND 10u
C22 +3V3 GND 10u
C26 +3V3 GND 0.1u
C34 GND -12V 10u
C21 +12V GND 10u
C31 GND -12V 0.1u
C25 +12V GND 0.1u
U2 -12V NC_10 /VOUT1 /VOUT2 +3V3 NC_11 /DAC_SYNC /DAC_SCK /DAC_SDIN GND +3V3 NC_12 NC_13 +3V3 GND Net-_U2-Pad16_ /DAC_REF2V5 GND GND GND GND /VOUT4 /VOUT3 +12V -12V AD5754BREZ
U3 -12V NC_14 /VOUT5 /VOUT6 +3V3 NC_15 /DAC_SYNC /DAC_SCK Net-_U2-Pad16_ GND +3V3 NC_16 NC_17 +3V3 GND NC_18 /DAC_REF2V5 GND GND GND GND /VOUT8 /VOUT7 +12V -12V AD5754BREZ
R36 /MIDI_TX /MIDI_TX_PIN4 220
R3 /IN2 /DIN2 4.7k
R4 /IN1 /DIN1 4.7k
D3 /IN2 GND D
D2 +3V3 /IN2 D
D4 +3V3 /IN1 D
D5 /IN1 GND D
BB1 GND /VIN1 /VGND1 /VIN2 /VGND2 /VIN3 /VGND3 /VIN4 /VGND4 /VIN5 /VGND5 /VIN6 /VGND6 /VIN7 /VGND7 /MIDI_TX_PIN2 /MIDI_TX_PIN4 /DIN1 /DIN2 NC_19 /VIN8 /VGND8 /VOUT1 /VOUT2 /VOUT3 /VOUT4 /VOUT5 /VOUT6 /VOUT7 /VOUT8 /TFT_SCK /TFT_MOSI /TFT_DC /TFT_CS /MIDI_RX_PIN2 /MIDI_RX_PIN4 /ENC1A /ENC1B /ENC1SW +5V NC_20 NC_21 NC_22 GND NC_23 NC_24 NC_25 NC_26 TEL-breakout
R1 +3V3 /ADC_RESET 4.7k
U4 GND /MIDI_RX /MIDI_TX /TFT_DC /ADC_BUSY /ADC_RESET /ADC_CONVST /TFT_CS NC_27 NC_28 NC_29 NC_30 /TFT_MOSI NC_31 NC_32 /IN2 /IN1 /DAC_SDIN /DAC_SCK /ENC1A /ENC1B /ENC1SW NC_33 NC_34 NC_35 NC_36 NC_37 /ADC_CS /ADC_RANGE /DAC_SYNC /MISO1 NC_38 NC_39 GND /TFT_SCK NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 +3V3 GND +5V Teensy4.1
J3 /MISO1 /ADC_MISO /MISO2 Conn_01x03
J1 /DAC_SCK /ADC_SCK /SCK2 Conn_01x03
J2 /MISO2 /SCK2 Conn_01x02
C20 +3V3 GND 10u
.end
