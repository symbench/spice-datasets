.title KiCad schematic
U2 /MISO /MOSI NC_01 VCC GND NC_02 NC_03 NC_04 NC_05 Net-_C5-Pad1_ Net-_C4-Pad1_ /SCK NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 Net-_C3-Pad1_ GND NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 /RESET NC_22 ATMEGA16M1
R1 VCC Net-_C3-Pad1_ R_100
C3 Net-_C3-Pad1_ GND C_100pF
Y1 Net-_C4-Pad1_ GND Net-_C5-Pad1_ GND Crystal_SMD
C4 Net-_C4-Pad1_ GND C_30pF
C5 Net-_C5-Pad1_ GND C_30pF
R3 VCC /RESET R_10K
J1 /MISO VCC /SCK /MOSI /RESET GND CONN_02X03
C2 VCC GND C_0.1uF
J15 GND /12V /5V_BMS /MISO_BMS /MOSI_BMS /SCK_BMS /RESET_BMS /RJ45_LED_O_BMS /RJ45_LED_G_BMS /CAN_HIGH /CAN_LOW NC_23 NC_24 /BMS_SENSE_OUT GND GND GND GND NC_25 GND MM_M_VT_20
J3 GND /12V /5V_BMS /MISO_BMS /MOSI_BMS /SCK_BMS /RESET_BMS /RJ45_LED_O_BMS /RJ45_LED_G_BMS /CAN_HIGH /CAN_LOW NC_26 NC_27 /BMS_SENSE GND GND GND GND NC_28 GND MM_F_VT_20
J4 GND /12V /5V_AIRC /MISO_AIRC /MOSI_AIRC /SCK_AIRC /RESET_AIRC /RJ45_LED_O_AIRC /RJ45_LED_G_AIRC /CAN_HIGH /CAN_LOW NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 /BMS_SENSE /IMD_SENSE GND MM_F_VT_20
J16 GND /12V /5V_AIRC /MISO_AIRC /MOSI_AIRC /SCK_AIRC /RESET_AIRC /RJ45_LED_O_AIRC /RJ45_LED_G_AIRC /CAN_HIGH /CAN_LOW NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 /BMS_SENSE_OUT /IMD_SENSE_OUT GND MM_M_VT_20
J7 GND /12V /IMD_SENSE GND MM_F_VT_04
J13 GND /12V /IMD_SENSE_OUT GND MM_M_VT_04
J6 GND /12V NC_41 NC_42 NC_43 NC_44 MM_F_VT_06
J12 GND /12V NC_45 NC_46 NC_47 NC_48 MM_M_VT_06
J10 NC_49 /Final_Shutdown_OUT NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 GND /Final_Shutdown_OUT MicroFit_VT_12
J9 NC_58 /Final_Shutdown NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 GND /Final_Shutdown MicroFit_VT_12
J2 NC_67 NC_68 NC_69 NC_70 NanoFit_RA_TH_04
J14 NC_71 GND /12V GND GND UF_5_VT
J8 NC_72 GND NC_73 GND GND UF_5_VT
J11 NC_74 NC_75 MicroFit_V_2
J5 NC_76 NC_77 MicroFit_V_2
. . . .
. . . .
.end
