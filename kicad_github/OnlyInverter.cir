.title KiCad schematic
J2 /LIN1 /LIN2 /LIN3 Conn_01x03
J1 /HIN1 /HIN2 /HIN3 Conn_01x03
R5 /BATT_VOLTAGE GNDREF 13K
R4 Net-_Q2-Pad2_ /BATT_VOLTAGE 150K
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ GNDREF BC547
R2 /V_BAT+ Net-_Q1-Pad1_ 10K
R1 Net-_Q1-Pad2_ /READ_CMD 10K
C5 /3V3 GNDREF C_Small
C4 /5V GNDREF C_Small
D1 GNDREF Net-_D1-Pad2_ LED
R6 /3V3 Net-_D1-Pad2_ R
U3 /3V3 GNDREF /5V LP2950-3.3_TO92
J6 /EXTIA /EXTIB /EXTIC Conn_01x03
R30 /5V /EXTIC R
R29 /5V /EXTIB R
R28 /5V /EXTIA R
C19 /5V GNDREF 1
C18 /5V GNDREF 1
J4 /PHASE_A /PHASE_B /PHASE_C Conn_01x03
C27 /BEMF_C GNDREF C_Small
R32 /BEMF_C GNDREF R
R31 /PHASE_C /BEMF_C R
C22 /BEMF_B GNDREF C_Small
R24 /BEMF_B GNDREF R
R23 /PHASE_B /BEMF_B R
C21 /BEMF_A GNDREF C_Small
R22 /BEMF_A GNDREF R
R21 /PHASE_A /BEMF_A R
C20 /BEMF_REF GNDREF C_Small
R19 /BEMF_REF GNDREF R
R18 Net-_R16-Pad2_ /BEMF_REF R
R20 /PHASE_C Net-_R16-Pad2_ R
R17 /PHASE_B Net-_R16-Pad2_ R
R16 /PHASE_A Net-_R16-Pad2_ R
U8 /EXTIC /BEMF_REF /BEMF_C GNDREF /5V LM393
U7 /EXTIA /BEMF_REF /BEMF_A GNDREF /BEMF_B /BEMF_REF /EXTIB /5V LM393
R3 /CURRENT_SENSOR Net-_R3-Pad2_ R
C3 /CURRENT_SENSOR GNDREF C_Small
0.1uF1 /3V3 GNDREF C_Small
U2 /3V3 GNDREF Net-_R3-Pad2_ GNDREF /CP ACS754
C2 /5V GNDREF 0.1uF
C1 /12V_Bootstrap GNDREF CP1
U1 /12V_Bootstrap GNDREF /5V L7805
C8 /12V_Bootstrap GNDREF 10uF
C11 /12V_Bootstrap GNDREF 100nF
C6 /12V_Bootstrap GNDREF 10uF
C9 /12V_Bootstrap GNDREF 100nF
C7 /12V_Bootstrap GNDREF 10uF
C10 /12V_Bootstrap GNDREF 100nF
C14 /PHASE_C Net-_C14-Pad2_ 10uF
C12 /PHASE_B Net-_C12-Pad2_ 10uF
C13 /PHASE_A Net-_C13-Pad2_ 10uF
R14 Net-_D6-Pad2_ /CP 10K
R15 Net-_D8-Pad2_ /CP 10K
R13 Net-_D10-Pad2_ /CP 10K
C17 Net-_C14-Pad2_ /PHASE_C 100nF
D4 Net-_C14-Pad2_ /12V_Bootstrap 1N4148
D10 Net-_D10-Pad1_ Net-_D10-Pad2_ 1N4148
D9 Net-_D9-Pad1_ Net-_D9-Pad2_ 1N4148
FQP85N6 /PHASE_C Net-_D10-Pad2_ /CP Q_NMOS_DGS
FQP85N5 /V_BAT+ Net-_D9-Pad2_ /PHASE_C Q_NMOS_DGS
U6 /12V_Bootstrap /HIN3 /LIN3 GNDREF Net-_D10-Pad1_ /PHASE_C Net-_D9-Pad1_ Net-_C14-Pad2_ IR2101
R12 Net-_D10-Pad1_ Net-_D10-Pad2_ 22
R11 Net-_D9-Pad2_ Net-_D9-Pad1_ 22
C15 Net-_C12-Pad2_ /PHASE_B 100nF
D3 Net-_C12-Pad2_ /12V_Bootstrap 1N4148
D8 Net-_D8-Pad1_ Net-_D8-Pad2_ 1N4148
D7 Net-_D7-Pad1_ Net-_D7-Pad2_ 1N4148
FQP85N4 /PHASE_B Net-_D8-Pad2_ /CP Q_NMOS_DGS
FQP85N3 /V_BAT+ Net-_D7-Pad2_ /PHASE_B Q_NMOS_DGS
U5 /12V_Bootstrap /HIN2 /LIN2 GNDREF Net-_D8-Pad1_ /PHASE_B Net-_D7-Pad1_ Net-_C12-Pad2_ IR2101
R10 Net-_D8-Pad1_ Net-_D8-Pad2_ 22
R9 Net-_D7-Pad2_ Net-_D7-Pad1_ 22
C16 Net-_C13-Pad2_ /PHASE_A 100nF
D2 Net-_C13-Pad2_ /12V_Bootstrap 1N4148
D6 Net-_D6-Pad1_ Net-_D6-Pad2_ 1N4148
D5 Net-_D5-Pad1_ Net-_D5-Pad2_ 1N4148
FQP85N2 /PHASE_A Net-_D6-Pad2_ /CP Q_NMOS_DGS
U4 /12V_Bootstrap /HIN1 /LIN1 GNDREF Net-_D6-Pad1_ /PHASE_A Net-_D5-Pad1_ Net-_C13-Pad2_ IR2101
R8 Net-_D6-Pad1_ Net-_D6-Pad2_ 22
R7 Net-_D5-Pad2_ Net-_D5-Pad1_ 22
J3 /READ_CMD /BATT_VOLTAGE /CURRENT_SENSOR Conn_01x03
J5 /V_BAT+ GNDREF Conn_01x02
C26 /V_BAT+ GNDREF C
J7 /12V_Bootstrap GNDREF Conn_01x02
FQP85N1 /V_BAT+ Net-_D5-Pad2_ /PHASE_A Q_NMOS_DGS
R25 Net-_D5-Pad2_ /PHASE_A 10K
R26 Net-_D7-Pad2_ /PHASE_B 10K
R27 Net-_D9-Pad2_ /PHASE_C 10K
D11 /V_BAT+ /PHASE_A 1N5819
D12 /PHASE_A /CP 1N5819
D13 /V_BAT+ /PHASE_B 1N5819
D14 /PHASE_B /CP 1N5819
D15 /V_BAT+ /PHASE_C 1N5819
D16 /PHASE_C /CP 1N5819
Q2 Net-_Q1-Pad1_ Net-_Q2-Pad2_ /V_BAT+ IRF9530
.end
