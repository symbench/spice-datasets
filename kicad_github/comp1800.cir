.title KiCad schematic
Kesc1 col1 Net-_D1-Pad2_ KEYSW
D1 row1 Net-_D1-Pad2_ D
Kf1b1 col2 Net-_D2-Pad2_ KEYSW
D2 row1 Net-_D2-Pad2_ D
Kprnt1 col16 Net-_D15-Pad2_ KEYSW
D15 row1 Net-_D15-Pad2_ D
Kscrll1 col17 Net-_D16-Pad2_ KEYSW
D16 row1 Net-_D16-Pad2_ D
Kpause1 col18 Net-_D17-Pad2_ KEYSW
D17 row1 Net-_D17-Pad2_ D
Kdel1 col19 Net-_D18-Pad2_ KEYSW
D18 row1 Net-_D18-Pad2_ D
Ktilde1 col1 Net-_D19-Pad2_ KEYSW
D19 row2 Net-_D19-Pad2_ D
K1 col2 Net-_D20-Pad2_ KEYSW
D20 row2 Net-_D20-Pad2_ D
K2 col3 Net-_D21-Pad2_ KEYSW
D21 row2 Net-_D21-Pad2_ D
K3 col4 Net-_D22-Pad2_ KEYSW
D22 row2 Net-_D22-Pad2_ D
K4 col5 Net-_D23-Pad2_ KEYSW
D23 row2 Net-_D23-Pad2_ D
K5 col6 Net-_D24-Pad2_ KEYSW
D24 row2 Net-_D24-Pad2_ D
K6 col7 Net-_D25-Pad2_ KEYSW
D25 row2 Net-_D25-Pad2_ D
K7 col8 Net-_D26-Pad2_ KEYSW
D26 row2 Net-_D26-Pad2_ D
K8 col9 Net-_D27-Pad2_ KEYSW
D27 row2 Net-_D27-Pad2_ D
K9 col10 Net-_D28-Pad2_ KEYSW
D28 row2 Net-_D28-Pad2_ D
K0 col11 Net-_D29-Pad2_ KEYSW
D29 row2 Net-_D29-Pad2_ D
K-1 col12 Net-_D30-Pad2_ KEYSW
D30 row2 Net-_D30-Pad2_ D
K=1 col13 Net-_D31-Pad2_ KEYSW
D31 row2 Net-_D31-Pad2_ D
Kbsa1 col15 Net-_D32-Pad2_ KEYSW
D32 row3 Net-_D32-Pad2_ D
Kdel2 col15 Net-_D33-Pad2_ KEYSW
D33 row2 Net-_D33-Pad2_ D
Kbsb1 col15 Net-_D33-Pad2_ KEYSW
K7b1 col16 Net-_D52-Pad2_ KEYSW
D52 row3 Net-_D52-Pad2_ D
K8b1 col17 Net-_D53-Pad2_ KEYSW
D53 row3 Net-_D53-Pad2_ D
K9b1 col18 Net-_D54-Pad2_ KEYSW
D54 row3 Net-_D54-Pad2_ D
K+b1 col19 Net-_D55-Pad2_ KEYSW
D55 row3 Net-_D55-Pad2_ D
Ktab1 col1 Net-_D38-Pad2_ KEYSW
D38 row3 Net-_D38-Pad2_ D
q1 col2 Net-_D39-Pad2_ KEYSW
D39 row3 Net-_D39-Pad2_ D
w1 col3 Net-_D40-Pad2_ KEYSW
D40 row3 Net-_D40-Pad2_ D
e1 col4 Net-_D41-Pad2_ KEYSW
D41 row3 Net-_D41-Pad2_ D
r1 col5 Net-_D42-Pad2_ KEYSW
D42 row3 Net-_D42-Pad2_ D
t1 col6 Net-_D43-Pad2_ KEYSW
D43 row3 Net-_D43-Pad2_ D
y1 col7 Net-_D44-Pad2_ KEYSW
D44 row3 Net-_D44-Pad2_ D
u1 col8 Net-_D45-Pad2_ KEYSW
D45 row3 Net-_D45-Pad2_ D
i1 col9 Net-_D46-Pad2_ KEYSW
D46 row3 Net-_D46-Pad2_ D
o1 col10 Net-_D47-Pad2_ KEYSW
D47 row3 Net-_D47-Pad2_ D
K10 col11 Net-_D48-Pad2_ KEYSW
D48 row3 Net-_D48-Pad2_ D
K11 col12 Net-_D49-Pad2_ KEYSW
D49 row3 Net-_D49-Pad2_ D
K12 col13 Net-_D50-Pad2_ KEYSW
D50 row3 Net-_D50-Pad2_ D
Knum1 col16 Net-_D34-Pad2_ KEYSW
D34 row2 Net-_D34-Pad2_ D
K/b1 col17 Net-_D35-Pad2_ KEYSW
D35 row2 Net-_D35-Pad2_ D
K*b1 col18 Net-_D36-Pad2_ KEYSW
D36 row2 Net-_D36-Pad2_ D
K-b1 col19 Net-_D37-Pad2_ KEYSW
D37 row2 Net-_D37-Pad2_ D
Kcaps1 col1 Net-_D56-Pad2_ KEYSW
D56 row4 Net-_D56-Pad2_ D
a1 col2 Net-_D57-Pad2_ KEYSW
D57 row4 Net-_D57-Pad2_ D
s1 col3 Net-_D58-Pad2_ KEYSW
D58 row4 Net-_D58-Pad2_ D
d1 col4 Net-_D59-Pad2_ KEYSW
D59 row4 Net-_D59-Pad2_ D
f1 col5 Net-_D60-Pad2_ KEYSW
D60 row4 Net-_D60-Pad2_ D
g1 col6 Net-_D61-Pad2_ KEYSW
D61 row4 Net-_D61-Pad2_ D
h1 col7 Net-_D62-Pad2_ KEYSW
D62 row4 Net-_D62-Pad2_ D
j1 col8 Net-_D63-Pad2_ KEYSW
D63 row4 Net-_D63-Pad2_ D
k1 col9 Net-_D64-Pad2_ KEYSW
D64 row4 Net-_D64-Pad2_ D
l1 col10 Net-_D65-Pad2_ KEYSW
D65 row4 Net-_D65-Pad2_ D
;1 col11 Net-_;1-Pad2_ KEYSW
D66 row4 Net-_;1-Pad2_ D
K'1 col12 Net-_D67-Pad2_ KEYSW
D67 row4 Net-_D67-Pad2_ D
Kenter1 col13 Net-_D68-Pad2_ KEYSW
D68 row4 Net-_D68-Pad2_ D
K4b1 col16 Net-_D69-Pad2_ KEYSW
D69 row4 Net-_D69-Pad2_ D
K5b1 col17 Net-_D70-Pad2_ KEYSW
D70 row4 Net-_D70-Pad2_ D
K6b1 col18 Net-_D71-Pad2_ KEYSW
D71 row4 Net-_D71-Pad2_ D
K+c1 col19 Net-_D72-Pad2_ KEYSW
D72 row4 Net-_D72-Pad2_ D
Kshftc1 col1 Net-_D73-Pad2_ KEYSW
D73 row5 Net-_D73-Pad2_ D
D74 row5 Net-_D74-Pad2_ D
x1 col4 Net-_D76-Pad2_ KEYSW
D75 row5 Net-_D75-Pad2_ D
c1 col5 Net-_D77-Pad2_ KEYSW
D76 row5 Net-_D76-Pad2_ D
v1 col6 Net-_D78-Pad2_ KEYSW
D77 row5 Net-_D77-Pad2_ D
b1 col7 Net-_D79-Pad2_ KEYSW
D78 row5 Net-_D78-Pad2_ D
n1 col8 Net-_D80-Pad2_ KEYSW
D79 row5 Net-_D79-Pad2_ D
m1 col9 Net-_D81-Pad2_ KEYSW
D80 row5 Net-_D80-Pad2_ D
K,1 col10 Net-_D82-Pad2_ KEYSW
D81 row5 Net-_D81-Pad2_ D
K.1 col11 Net-_D83-Pad2_ KEYSW
D82 row5 Net-_D82-Pad2_ D
K/a1 col12 Net-_D84-Pad2_ KEYSW
D83 row5 Net-_D83-Pad2_ D
K/b2 col12 Net-_D84-Pad2_ KEYSW
D84 row5 Net-_D84-Pad2_ D
Kshftb1 col1 Net-_D73-Pad2_ KEYSW
K1b1 col16 Net-_D86-Pad2_ KEYSW
D86 row5 Net-_D86-Pad2_ D
K2b1 col17 Net-_D87-Pad2_ KEYSW
D87 row5 Net-_D87-Pad2_ D
K3b1 col18 Net-_D88-Pad2_ KEYSW
D88 row5 Net-_D88-Pad2_ D
K1ua1 col19 Net-_D89-Pad2_ KEYSW
D89 row5 Net-_D89-Pad2_ D
Kctrlb1 col1 Net-_D90-Pad2_ KEYSW
D90 row6 Net-_D90-Pad2_ D
Kwinb1 col2 Net-_D91-Pad2_ KEYSW
D91 row6 Net-_D91-Pad2_ D
Kaltb1 col3 Net-_D92-Pad2_ KEYSW
D92 row6 Net-_D92-Pad2_ D
Kspaceg1 col7 Net-_D94-Pad2_ KEYSW
D94 row6 Net-_D94-Pad2_ D
D96 row6 Net-_D96-Pad2_ D
Kctrld1 col12 Net-_D97-Pad2_ KEYSW
D97 row6 Net-_D97-Pad2_ D
Kmenu1 col13 Net-_D98-Pad2_ KEYSW
D98 row6 Net-_D98-Pad2_ D
Kaltd1 col15 Net-_D99-Pad2_ KEYSW
D99 row6 Net-_D99-Pad2_ D
K0c1 col17 Net-_D101-Pad2_ KEYSW
D101 row6 Net-_D101-Pad2_ D
K.b1 col18 Net-_D102-Pad2_ KEYSW
D102 row6 Net-_D102-Pad2_ D
Kenterc1 col19 Net-_D103-Pad2_ KEYSW
D103 row6 Net-_D103-Pad2_ D
z1 col3 Net-_D75-Pad2_ KEYSW
Kfn1 col13 Net-_D85-Pad2_ KEYSW
D85 row5 Net-_D85-Pad2_ D
Kshfte1 col13 Net-_D85-Pad2_ KEYSW
Kf1a1 col2 Net-_D2-Pad2_ KEYSW
Kf2b1 col3 Net-_D3-Pad2_ KEYSW
D3 row1 Net-_D3-Pad2_ D
Kf2a1 col3 Net-_D3-Pad2_ KEYSW
Kf3b1 col4 Net-_D4-Pad2_ KEYSW
D4 row1 Net-_D4-Pad2_ D
Kf3a1 col4 Net-_D4-Pad2_ KEYSW
Kf4b1 col5 Net-_D5-Pad2_ KEYSW
D5 row1 Net-_D5-Pad2_ D
Kf4a1 col5 Net-_D5-Pad2_ KEYSW
Kf5b1 col6 Net-_D6-Pad2_ KEYSW
D6 row1 Net-_D6-Pad2_ D
Kf5a1 col6 Net-_D6-Pad2_ KEYSW
Kf6b1 col7 Net-_D7-Pad2_ KEYSW
D7 row1 Net-_D7-Pad2_ D
Kf6a1 col7 Net-_D7-Pad2_ KEYSW
Kf7b1 col8 Net-_D8-Pad2_ KEYSW
D8 row1 Net-_D8-Pad2_ D
Kf7a1 col8 Net-_D8-Pad2_ KEYSW
Kf8b1 col9 Net-_D9-Pad2_ KEYSW
D9 row1 Net-_D9-Pad2_ D
Kf8a1 col9 Net-_D9-Pad2_ KEYSW
Kf9b1 col10 Net-_D10-Pad2_ KEYSW
D10 row1 Net-_D10-Pad2_ D
Kf9a1 col10 Net-_D10-Pad2_ KEYSW
Kf10b1 col11 Net-_D11-Pad2_ KEYSW
D11 row1 Net-_D11-Pad2_ D
Kf10a1 col11 Net-_D11-Pad2_ KEYSW
Kf11b1 col12 Net-_D12-Pad2_ KEYSW
D12 row1 Net-_D12-Pad2_ D
Kf11a1 col12 Net-_D12-Pad2_ KEYSW
Kf12b1 col13 Net-_D13-Pad2_ KEYSW
D13 row1 Net-_D13-Pad2_ D
Kf12a1 col13 Net-_D13-Pad2_ KEYSW
D14 row1 Net-_D14-Pad2_ D
Kesc2 col15 Net-_D14-Pad2_ KEYSW
K0b1 col16 Net-_D100-Pad2_ KEYSW
D100 row6 Net-_D100-Pad2_ D
Kctrla1 col1 Net-_D90-Pad2_ KEYSW
Kwina1 col2 Net-_D91-Pad2_ KEYSW
Kalta1 col3 Net-_D92-Pad2_ KEYSW
Kspacef1 col7 Net-_D94-Pad2_ KEYSW
kctrlc1 col11 Net-_D96-Pad2_ KEYSW
Kwinc1 col12 Net-_D97-Pad2_ KEYSW
Kwind1 col13 Net-_D98-Pad2_ KEYSW
Kaltc1 col15 Net-_D99-Pad2_ KEYSW
Kspaced1 col7 Net-_D94-Pad2_ KEYSW
D93 row6 Net-_D93-Pad2_ D
Kspaceb1 col5 Net-_D93-Pad2_ KEYSW
D95 row6 Net-_D95-Pad2_ D
Kspacei1 col9 Net-_D95-Pad2_ KEYSW
Kspacea1 col5 Net-_D93-Pad2_ KEYSW
Kspaceh1 col9 Net-_D95-Pad2_ KEYSW
Kspacec1 col7 Net-_D94-Pad2_ KEYSW
Kenterb1 col19 Net-_D103-Pad2_ KEYSW
k1u1 col19 Net-_D72-Pad2_ KEYSW
Kiso1u1 col2 Net-_D74-Pad2_ KEYSW
D51 row4 Net-_D51-Pad2_ D
K\1 NC_01 Net-_D51-Pad2_ KEYSW
U1 NC_02 col19 col18 col17 col16 col12 col9 col8 col7 col6 col11 col10 col4 NC_03 NC_04 NC_05 col5 col3 col2 col15 NC_06 col13 row1 row2 row3 row4 row5 row6 NC_07 NC_08 col1 TEENSY2.0
.end
