.title KiCad schematic
U8 /ETH0_A_P /ETH0_A_N /A2V5_1 /ETH0_B_P /ETH0_B_N /A1V0_1 /ETH0_C_P /ETH0_C_N /A2V5_1 /ETH0_D_P /ETH0_D_N Net-_R20-Pad2_ /A1V8_1 NC_01 /CLK_25MHZ_0 /MGMT_MDC /MGMT_MDIO NC_02 /1V8 /JTAG_TCK /JTAG_TDO_0 /JTAG_TMS NC_03 /A1V0_1 NC_04 NC_05 /SGMII0_TX_C_P /SGMII0_TX_C_N NC_06 /1V8 /A1V0_1 NC_07 NC_08 NC_09 /SGMII0_RX_C_P /SGMII0_RX_C_N NC_10 /RX_CTRL_0 NC_11 NC_12 /1V8 /A1V0_1 /PHY_RST_N Net-_R21-Pad2_ NC_13 /LED_1_0 /LED_0_0 /A1V8_1 /GND DP83867
R20 /GND Net-_R20-Pad2_ 11K
R21 /1V8 Net-_R21-Pad2_ 10k
C12 /SGMII0_TX_C_P NC_14 0.1 uF
C13 /SGMII0_TX_C_N NC_15 0.1 uF
C14 /SGMII0_RX_C_P NC_16 0.1 uF
C15 /SGMII0_RX_C_N NC_17 0.1 uF
C21 /A2V5_1 /GND 4.7 uF
C25 /A2V5_1 /GND 0.47 uF
C28 /A2V5_1 /GND 0.47 uF
C22 /A1V8_1 /GND 4.7 uF
C26 /A1V8_1 /GND 0.47 uF
C29 /A1V8_1 /GND 0.47 uF
C23 /A1V0_1 /GND 4.7 uF
C27 /A1V0_1 /GND 0.47 uF
C30 /A1V0_1 /GND 0.47 uF
C31 /A1V0_1 /GND 0.47 uF
C32 /A1V0_1 /GND 0.47 uF
C16 /1V8 /GND 0.47 uF
C20 /1V8 /GND 0.47 uF
C24 /1V8 /GND 0.47 uF
R28 /1V8 /MGMT_MDIO 2.0K
R22 /RX_CTRL_0 /1V8 5.76K
R23 /GND /RX_CTRL_0 2.49K
Q1 Net-_Q1-PadD1_ Net-_Q1-PadD2_ /LED_1_0 /LED_0_0 /GND /GND SSM6N58NU
R24 /LED1_0_N Net-_Q1-PadD1_ 470
R27 /LED0_0_N Net-_Q1-PadD2_ 470
R25 /1V8 /LED_0_0 10K
R26 /LED_0_0 /GND 2.49K
L7 Net-_L7-Pad1_ /ETH0_AM_P /ETH0_AM_N Net-_L7-Pad4_ /ETH0_BM_N /ETH0_BM_P Net-_L7-Pad7_ /ETH0_CM_P /ETH0_CM_N Net-_L7-Pad10_ /ETH0_DM_N /ETH0_DM_P /ETH0_D_N /ETH0_D_P Net-_C46-Pad2_ /ETH0_C_N /ETH0_C_P Net-_C47-Pad2_ /ETH0_B_N /ETH0_B_P Net-_C48-Pad2_ /ETH0_A_N /ETH0_A_P Net-_C49-Pad2_ BOURNS_PT6120EL
C49 /GND Net-_C49-Pad2_ 0.1 uF
C48 /GND Net-_C48-Pad2_ 0.1 uF
C47 /GND Net-_C47-Pad2_ 0.1 uF
C46 /GND Net-_C46-Pad2_ 0.1 uF
R29 Net-_C50-Pad2_ Net-_L7-Pad1_ 75
R30 Net-_C50-Pad2_ Net-_L7-Pad4_ 75
R31 Net-_C50-Pad2_ Net-_L7-Pad7_ 75
R32 Net-_C50-Pad2_ Net-_L7-Pad10_ 75
C50 /SHIELD Net-_C50-Pad2_ 10 nF 2 kV
J2 /ETH0_AM_P /ETH0_AM_N /ETH0_BM_P /ETH0_CM_P /ETH0_CM_N /ETH0_BM_N /ETH0_DM_P /ETH0_DM_N /3V3 /LED0_0_N /3V3 /LED1_0_N /ETH1_AM_P /ETH1_AM_N /ETH1_BM_P /ETH1_CM_P /ETH1_CM_N /ETH1_BM_N /ETH1_DM_P /ETH1_DM_N /3V3 /LED0_1_N /3V3 /LED1_1_N /ETH2_AM_P /ETH2_AM_N /ETH2_BM_P /ETH2_CM_P /ETH2_CM_N /ETH2_BM_N /ETH2_DM_P /ETH2_DM_N /3V3 /LED0_2_N /3V3 /LED1_2_N /ETH3_AM_P /ETH3_AM_N /ETH3_BM_P /ETH3_CM_P /ETH3_CM_N /ETH3_BM_N /ETH3_DM_P /ETH3_DM_N /3V3 /LED0_3_N /3V3 /LED1_3_N /ETH4_AM_P /ETH4_AM_N /ETH4_BM_P /ETH4_CM_P /ETH4_CM_N /ETH4_BM_N /ETH4_DM_P /ETH4_DM_N /3V3 /LED0_4_N /3V3 /LED1_4_N /ETH5_AM_P /ETH5_AM_N /ETH5_BM_P /ETH5_CM_P /ETH5_CM_N /ETH5_BM_N /ETH5_DM_P /ETH5_DM_N /3V3 /LED0_5_N /3V3 /LED1_5_N /ETH6_AM_P /ETH6_AM_N /ETH6_BM_P /ETH6_CM_P /ETH6_CM_N /ETH6_BM_N /ETH6_DM_P /ETH6_DM_N /3V3 /LED0_6_N /3V3 /LED1_6_N /ETH7_AM_P /ETH7_AM_N /ETH7_BM_P /ETH7_CM_P /ETH7_CM_N /ETH7_BM_N /ETH7_DM_P /ETH7_DM_N /3V3 /LED0_7_N /3V3 /LED1_7_N /SHIELD STEWART_SS_74500_024
U9 /ETH1_A_P /ETH1_A_N /A2V5_1 /ETH1_B_P /ETH1_B_N /A1V0_1 /ETH1_C_P /ETH1_C_N /A2V5_1 /ETH1_D_P /ETH1_D_N Net-_R33-Pad2_ /A1V8_1 NC_18 /CLK_25MHZ_1 /MGMT_MDC /MGMT_MDIO NC_19 /1V8 /JTAG_TCK /JTAG_TDO_1 /JTAG_TMS /JTAG_TDO_0 /A1V0_1 NC_20 NC_21 /SGMII1_TX_C_P /SGMII1_TX_C_N NC_22 /1V8 /A1V0_1 NC_23 /RX_D0_1 NC_24 /SGMII1_RX_C_P /SGMII1_RX_C_N NC_25 /RX_CTRL_1 NC_26 NC_27 /1V8 /A1V0_1 /PHY_RST_N Net-_R34-Pad2_ NC_28 /LED_1_1 /LED_0_1 /A1V8_1 /GND DP83867
L8 /A2V5_1 /2V5 600R
L10 /A1V0_1 /1V0 600R
L9 /A1V8_1 /1V8 600R
R33 /GND Net-_R33-Pad2_ 11K
R34 /1V8 Net-_R34-Pad2_ 10k
C51 /SGMII1_TX_C_P NC_29 0.1 uF
C52 /SGMII1_TX_C_N NC_30 0.1 uF
C53 /SGMII1_RX_C_P NC_31 0.1 uF
C54 /SGMII1_RX_C_N NC_32 0.1 uF
C64 /2V5 /GND 4.7 uF
C78 /A2V5_1 /GND 4.7 uF
C93 /A2V5_1 /GND 0.47 uF
C105 /A2V5_1 /GND 0.47 uF
C65 /1V8 /GND 4.7 uF
C79 /A1V8_1 /GND 4.7 uF
C94 /A1V8_1 /GND 0.47 uF
C106 /A1V8_1 /GND 0.47 uF
C66 /1V0 /GND 4.7 uF
C80 /A1V0_1 /GND 4.7 uF
C95 /A1V0_1 /GND 0.47 uF
C107 /A1V0_1 /GND 0.47 uF
C117 /A1V0_1 /GND 0.47 uF
C123 /A1V0_1 /GND 0.47 uF
C63 /1V8 /GND 0.47 uF
C75 /1V8 /GND 0.47 uF
C87 /1V8 /GND 0.47 uF
R39 /RX_CTRL_1 /1V8 5.76K
R45 /GND /RX_CTRL_1 2.49K
Q2 Net-_Q2-PadD1_ Net-_Q2-PadD2_ /LED_1_1 /LED_0_1 /GND /GND SSM6N58NU
R57 /LED1_1_N Net-_Q2-PadD1_ 470
Q3 Net-_Q3-PadD1_ Net-_Q3-PadD2_ /LED_1_2 /LED_0_2 /GND /GND SSM6N58NU
R71 /LED0_1_N Net-_Q2-PadD2_ 470
R65 /1V8 /LED_0_1 10K
R66 /LED_0_1 /GND 2.49K
L17 Net-_L17-Pad1_ /ETH1_AM_P /ETH1_AM_N Net-_L17-Pad4_ /ETH1_BM_N /ETH1_BM_P Net-_L17-Pad7_ /ETH1_CM_P /ETH1_CM_N Net-_L17-Pad10_ /ETH1_DM_N /ETH1_DM_P /ETH1_D_N /ETH1_D_P Net-_C90-Pad2_ /ETH1_C_N /ETH1_C_P Net-_C102-Pad2_ /ETH1_B_N /ETH1_B_P Net-_C114-Pad2_ /ETH1_A_N /ETH1_A_P Net-_C120-Pad2_ BOURNS_PT6120EL
C120 /GND Net-_C120-Pad2_ 0.1 uF
C114 /GND Net-_C114-Pad2_ 0.1 uF
C102 /GND Net-_C102-Pad2_ 0.1 uF
C90 /GND Net-_C90-Pad2_ 0.1 uF
R50 Net-_C126-Pad2_ Net-_L17-Pad1_ 75
R53 Net-_C126-Pad2_ Net-_L17-Pad4_ 75
R56 Net-_C126-Pad2_ Net-_L17-Pad7_ 75
R62 Net-_C126-Pad2_ Net-_L17-Pad10_ 75
C126 /SHIELD Net-_C126-Pad2_ 10 nF 2 kV
R40 /RX_D0_1 /1V8 10K
R46 /GND /RX_D0_1 2.49K
U10 /ETH2_A_P /ETH2_A_N /A2V5_3 /ETH2_B_P /ETH2_B_N /A1V0_3 /ETH2_C_P /ETH2_C_N /A2V5_3 /ETH2_D_P /ETH2_D_N Net-_R35-Pad2_ /A1V8_3 NC_33 /CLK_25MHZ_2 /MGMT_MDC /MGMT_MDIO NC_34 /1V8 /JTAG_TCK /JTAG_TDO_2 /JTAG_TMS /JTAG_TDO_1 /A1V0_3 NC_35 NC_36 /SGMII2_TX_C_P /SGMII2_TX_C_N NC_37 /1V8 /A1V0_3 NC_38 /RX_D0_2 NC_39 /SGMII2_RX_C_P /SGMII2_RX_C_N NC_40 /RX_CTRL_2 NC_41 NC_42 /1V8 /A1V0_3 /PHY_RST_N Net-_R36-Pad2_ NC_43 /LED_1_2 /LED_0_2 /A1V8_3 /GND DP83867
R35 /GND Net-_R35-Pad2_ 11K
R36 /1V8 Net-_R36-Pad2_ 10k
C55 /SGMII2_TX_C_P NC_44 0.1 uF
C56 /SGMII2_TX_C_N NC_45 0.1 uF
C57 /SGMII2_RX_C_P NC_46 0.1 uF
C58 /SGMII2_RX_C_N NC_47 0.1 uF
C81 /A2V5_3 /GND 4.7 uF
C96 /A2V5_3 /GND 0.47 uF
C108 /A2V5_3 /GND 0.47 uF
C82 /A1V8_3 /GND 4.7 uF
C97 /A1V8_3 /GND 0.47 uF
C109 /A1V8_3 /GND 0.47 uF
C83 /A1V0_3 /GND 4.7 uF
C98 /A1V0_3 /GND 0.47 uF
C110 /A1V0_3 /GND 0.47 uF
C118 /A1V0_3 /GND 0.47 uF
C124 /A1V0_3 /GND 0.47 uF
C67 /1V8 /GND 0.47 uF
C76 /1V8 /GND 0.47 uF
C88 /1V8 /GND 0.47 uF
R41 /RX_CTRL_2 /1V8 5.76K
R47 /GND /RX_CTRL_2 2.49K
R59 /LED1_2_N Net-_Q3-PadD1_ 470
Q4 Net-_Q4-PadD1_ Net-_Q4-PadD2_ /LED_1_3 /LED_0_3 /GND /GND SSM6N58NU
R72 /LED0_2_N Net-_Q3-PadD2_ 470
R67 /1V8 /LED_0_2 10K
R68 /LED_0_2 /GND 2.49K
L18 Net-_L18-Pad1_ /ETH2_AM_P /ETH2_AM_N Net-_L18-Pad4_ /ETH2_BM_N /ETH2_BM_P Net-_L18-Pad7_ /ETH2_CM_P /ETH2_CM_N Net-_L18-Pad10_ /ETH2_DM_N /ETH2_DM_P /ETH2_D_N /ETH2_D_P Net-_C91-Pad2_ /ETH2_C_N /ETH2_C_P Net-_C103-Pad2_ /ETH2_B_N /ETH2_B_P Net-_C115-Pad2_ /ETH2_A_N /ETH2_A_P Net-_C121-Pad2_ BOURNS_PT6120EL
C121 /GND Net-_C121-Pad2_ 0.1 uF
C115 /GND Net-_C115-Pad2_ 0.1 uF
C103 /GND Net-_C103-Pad2_ 0.1 uF
C91 /GND Net-_C91-Pad2_ 0.1 uF
R51 Net-_C127-Pad2_ Net-_L18-Pad1_ 75
R54 Net-_C127-Pad2_ Net-_L18-Pad4_ 75
R58 Net-_C127-Pad2_ Net-_L18-Pad7_ 75
R63 Net-_C127-Pad2_ Net-_L18-Pad10_ 75
C127 /SHIELD Net-_C127-Pad2_ 10 nF 2 kV
R42 /RX_D0_2 /1V8 5.76k
R48 /GND /RX_D0_2 2.49K
U11 /ETH3_A_P /ETH3_A_N /A2V5_3 /ETH3_B_P /ETH3_B_N /A1V0_3 /ETH3_C_P /ETH3_C_N /A2V5_3 /ETH3_D_P /ETH3_D_N Net-_R37-Pad2_ /A1V8_3 NC_48 /CLK_25MHZ_3 /MGMT_MDC /MGMT_MDIO NC_49 /1V8 /JTAG_TCK /JTAG_TDO_3 /JTAG_TMS /JTAG_TDO_2 /A1V0_3 NC_50 NC_51 /SGMII3_TX_C_P /SGMII3_TX_C_N NC_52 /1V8 /A1V0_3 NC_53 /RX_D0_3 NC_54 /SGMII3_RX_C_P /SGMII3_RX_C_N NC_55 /RX_CTRL_3 NC_56 NC_57 /1V8 /A1V0_3 /PHY_RST_N Net-_R38-Pad2_ NC_58 /LED_1_3 /LED_0_3 /A1V8_3 /GND DP83867
L14 /A2V5_3 /2V5 600R
L16 /A1V0_3 /1V0 600R
L15 /A1V8_3 /1V8 600R
R37 /GND Net-_R37-Pad2_ 11K
R38 /1V8 Net-_R38-Pad2_ 10k
C59 /SGMII3_TX_C_P NC_59 0.1 uF
C60 /SGMII3_TX_C_N NC_60 0.1 uF
C61 /SGMII3_RX_C_P NC_61 0.1 uF
C62 /SGMII3_RX_C_N NC_62 0.1 uF
C72 /2V5 /GND 4.7 uF
C84 /A2V5_3 /GND 4.7 uF
C99 /A2V5_3 /GND 0.47 uF
C111 /A2V5_3 /GND 0.47 uF
C73 /1V8 /GND 4.7 uF
C85 /A1V8_3 /GND 4.7 uF
C100 /A1V8_3 /GND 0.47 uF
C112 /A1V8_3 /GND 0.47 uF
C74 /1V0 /GND 4.7 uF
C86 /A1V0_3 /GND 4.7 uF
C101 /A1V0_3 /GND 0.47 uF
C113 /A1V0_3 /GND 0.47 uF
C119 /A1V0_3 /GND 0.47 uF
C125 /A1V0_3 /GND 0.47 uF
C71 /1V8 /GND 0.47 uF
C77 /1V8 /GND 0.47 uF
C89 /1V8 /GND 0.47 uF
R43 /RX_CTRL_3 /1V8 5.76K
R49 /GND /RX_CTRL_3 2.49K
R61 /LED1_3_N Net-_Q4-PadD1_ 470
R73 /LED0_3_N Net-_Q4-PadD2_ 470
R69 /1V8 /LED_0_3 10K
R70 /LED_0_3 /GND 2.49K
L19 Net-_L19-Pad1_ /ETH3_AM_P /ETH3_AM_N Net-_L19-Pad4_ /ETH3_BM_N /ETH3_BM_P Net-_L19-Pad7_ /ETH3_CM_P /ETH3_CM_N Net-_L19-Pad10_ /ETH3_DM_N /ETH3_DM_P /ETH3_D_N /ETH3_D_P Net-_C92-Pad2_ /ETH3_C_N /ETH3_C_P Net-_C104-Pad2_ /ETH3_B_N /ETH3_B_P Net-_C116-Pad2_ /ETH3_A_N /ETH3_A_P Net-_C122-Pad2_ BOURNS_PT6120EL
C122 /GND Net-_C122-Pad2_ 0.1 uF
C116 /GND Net-_C116-Pad2_ 0.1 uF
C104 /GND Net-_C104-Pad2_ 0.1 uF
C92 /GND Net-_C92-Pad2_ 0.1 uF
R52 Net-_C128-Pad2_ Net-_L19-Pad1_ 75
R55 Net-_C128-Pad2_ Net-_L19-Pad4_ 75
R60 Net-_C128-Pad2_ Net-_L19-Pad7_ 75
R64 Net-_C128-Pad2_ Net-_L19-Pad10_ 75
C128 /SHIELD Net-_C128-Pad2_ 10 nF 2 kV
R44 /RX_D0_3 /1V8 2.49K
U12 /ETH4_A_P /ETH4_A_N /A2V5_5 /ETH4_B_P /ETH4_B_N /A1V0_5 /ETH4_C_P /ETH4_C_N /A2V5_5 /ETH4_D_P /ETH4_D_N Net-_R74-Pad2_ /A1V8_5 NC_63 /CLK_25MHZ_4 /MGMT_MDC /MGMT_MDIO NC_64 /1V8 /JTAG_TCK /JTAG_TDO_4 /JTAG_TMS /JTAG_TDO_3 /A1V0_5 NC_65 NC_66 /SGMII4_TX_C_P /SGMII4_TX_C_N NC_67 /1V8 /A1V0_5 NC_68 NC_69 NC_70 /SGMII4_RX_C_P /SGMII4_RX_C_N NC_71 /RX_CTRL_4 NC_72 NC_73 /1V8 /A1V0_5 /PHY_RST_N Net-_R75-Pad2_ NC_74 /LED_1_4 /LED_0_4 /A1V8_5 /GND DP83867
R74 /GND Net-_R74-Pad2_ 11K
R75 /1V8 Net-_R75-Pad2_ 10k
C129 /SGMII4_TX_C_P NC_75 0.1 uF
C130 /SGMII4_TX_C_N NC_76 0.1 uF
C131 /SGMII4_RX_C_P NC_77 0.1 uF
C132 /SGMII4_RX_C_N NC_78 0.1 uF
C165 /A2V5_5 /GND 4.7 uF
C185 /A2V5_5 /GND 0.47 uF
C201 /A2V5_5 /GND 0.47 uF
C166 /A1V8_5 /GND 4.7 uF
C186 /A1V8_5 /GND 0.47 uF
C202 /A1V8_5 /GND 0.47 uF
C167 /A1V0_5 /GND 4.7 uF
C187 /A1V0_5 /GND 0.47 uF
C203 /A1V0_5 /GND 0.47 uF
C217 /A1V0_5 /GND 0.47 uF
C225 /A1V0_5 /GND 0.47 uF
C145 /1V8 /GND 0.47 uF
C161 /1V8 /GND 0.47 uF
C177 /1V8 /GND 0.47 uF
R82 /RX_CTRL_4 /1V8 5.76K
R97 /GND /RX_CTRL_4 2.49K
Q5 Net-_Q5-PadD1_ Net-_Q5-PadD2_ /LED_1_4 /LED_0_4 /GND /GND SSM6N58NU
R120 /LED1_4_N Net-_Q5-PadD1_ 470
Q7 Net-_Q7-PadD1_ Net-_Q7-PadD2_ /LED_1_5 /LED_0_5 /GND /GND SSM6N58NU
R139 /LED0_4_N Net-_Q5-PadD2_ 470
R131 /1V8 /LED_0_4 10K
R132 /LED_0_4 /GND 2.49K
L32 Net-_L32-Pad1_ /ETH4_AM_P /ETH4_AM_N Net-_L32-Pad4_ /ETH4_BM_N /ETH4_BM_P Net-_L32-Pad7_ /ETH4_CM_P /ETH4_CM_N Net-_L32-Pad10_ /ETH4_DM_N /ETH4_DM_P /ETH4_D_N /ETH4_D_P Net-_C181-Pad2_ /ETH4_C_N /ETH4_C_P Net-_C197-Pad2_ /ETH4_B_N /ETH4_B_P Net-_C213-Pad2_ /ETH4_A_N /ETH4_A_P Net-_C221-Pad2_ BOURNS_PT6120EL
C221 /GND Net-_C221-Pad2_ 0.1 uF
C213 /GND Net-_C213-Pad2_ 0.1 uF
C197 /GND Net-_C197-Pad2_ 0.1 uF
C181 /GND Net-_C181-Pad2_ 0.1 uF
R111 Net-_C229-Pad2_ Net-_L32-Pad1_ 75
R115 Net-_C229-Pad2_ Net-_L32-Pad4_ 75
R119 Net-_C229-Pad2_ Net-_L32-Pad7_ 75
R127 Net-_C229-Pad2_ Net-_L32-Pad10_ 75
C229 /SHIELD Net-_C229-Pad2_ 10 nF 2 kV
U13 /ETH5_A_P /ETH5_A_N /A2V5_5 /ETH5_B_P /ETH5_B_N /A1V0_5 /ETH5_C_P /ETH5_C_N /A2V5_5 /ETH5_D_P /ETH5_D_N Net-_R76-Pad2_ /A1V8_5 NC_79 /CLK_25MHZ_5 /MGMT_MDC /MGMT_MDIO NC_80 /1V8 /JTAG_TCK /JTAG_TDO_5 /JTAG_TMS /JTAG_TDO_4 /A1V0_5 NC_81 NC_82 /SGMII5_TX_C_P /SGMII5_TX_C_N NC_83 /1V8 /A1V0_5 NC_84 /RX_D0_5 NC_85 /SGMII5_RX_C_P /SGMII5_RX_C_N NC_86 /RX_CTRL_5 NC_87 NC_88 /1V8 /A1V0_5 /PHY_RST_N Net-_R77-Pad2_ NC_89 /LED_1_5 /LED_0_5 /A1V8_5 /GND DP83867
L23 /A2V5_5 /2V5 600R
L25 /A1V0_5 /1V0 600R
L24 /A1V8_5 /1V8 600R
R76 /GND Net-_R76-Pad2_ 11K
R77 /1V8 Net-_R77-Pad2_ 10k
C133 /SGMII5_TX_C_P NC_90 0.1 uF
C134 /SGMII5_TX_C_N NC_91 0.1 uF
C135 /SGMII5_RX_C_P NC_92 0.1 uF
C136 /SGMII5_RX_C_N NC_93 0.1 uF
C150 /2V5 /GND 4.7 uF
C168 /A2V5_5 /GND 4.7 uF
C188 /A2V5_5 /GND 0.47 uF
C204 /A2V5_5 /GND 0.47 uF
C151 /1V8 /GND 4.7 uF
C169 /A1V8_5 /GND 4.7 uF
C189 /A1V8_5 /GND 0.47 uF
C205 /A1V8_5 /GND 0.47 uF
C152 /1V0 /GND 4.7 uF
C170 /A1V0_5 /GND 4.7 uF
C190 /A1V0_5 /GND 0.47 uF
C206 /A1V0_5 /GND 0.47 uF
C218 /A1V0_5 /GND 0.47 uF
C226 /A1V0_5 /GND 0.47 uF
C149 /1V8 /GND 0.47 uF
C162 /1V8 /GND 0.47 uF
C178 /1V8 /GND 0.47 uF
R85 /RX_CTRL_5 /1V8 5.76K
R100 /GND /RX_CTRL_5 2.49K
R122 /LED1_5_N Net-_Q7-PadD1_ 470
R140 /LED0_5_N Net-_Q7-PadD2_ 470
R133 /1V8 /LED_0_5 10K
R134 /LED_0_5 /GND 2.49K
L33 Net-_L33-Pad1_ /ETH5_AM_N /ETH5_AM_P Net-_L33-Pad4_ /ETH5_BM_N /ETH5_BM_P Net-_L33-Pad7_ /ETH5_CM_P /ETH5_CM_N Net-_L33-Pad10_ /ETH5_DM_N /ETH5_DM_P /ETH5_D_N /ETH5_D_P Net-_C182-Pad2_ /ETH5_C_N /ETH5_C_P Net-_C198-Pad2_ /ETH5_B_N /ETH5_B_P Net-_C214-Pad2_ /ETH5_A_N /ETH5_A_P Net-_C222-Pad2_ BOURNS_PT6120EL
C222 /GND Net-_C222-Pad2_ 0.1 uF
C214 /GND Net-_C214-Pad2_ 0.1 uF
C198 /GND Net-_C198-Pad2_ 0.1 uF
C182 /GND Net-_C182-Pad2_ 0.1 uF
R112 Net-_C230-Pad2_ Net-_L33-Pad1_ 75
R116 Net-_C230-Pad2_ Net-_L33-Pad4_ 75
R121 Net-_C230-Pad2_ Net-_L33-Pad7_ 75
R128 Net-_C230-Pad2_ Net-_L33-Pad10_ 75
C230 /SHIELD Net-_C230-Pad2_ 10 nF 2 kV
R86 /RX_D0_5 /1V8 10K
R101 /GND /RX_D0_5 2.49K
U14 /ETH6_A_P /ETH6_A_N /A2V5_7 /ETH6_B_P /ETH6_B_N /A1V0_7 /ETH6_C_P /ETH6_C_N /A2V5_7 /ETH6_D_P /ETH6_D_N Net-_R78-Pad2_ /A1V8_7 NC_94 /CLK_25MHZ_6 /MGMT_MDC /MGMT_MDIO NC_95 /1V8 /JTAG_TCK /JTAG_TDO_6 /JTAG_TMS /JTAG_TDO_5 /A1V0_7 NC_96 NC_97 /SGMII6_TX_C_P /SGMII6_TX_C_N NC_98 /1V8 /A1V0_7 NC_99 /RX_D0_6 NC_100 /SGMII6_RX_C_P /SGMII6_RX_C_N NC_101 /RX_CTRL_6 NC_102 NC_103 /1V8 /A1V0_7 /PHY_RST_N Net-_R79-Pad2_ NC_104 /LED_1_6 /LED_0_6 /A1V8_7 /GND DP83867
R78 /GND Net-_R78-Pad2_ 11K
R79 /1V8 Net-_R79-Pad2_ 10k
C137 /SGMII6_TX_C_P NC_105 0.1 uF
C138 /SGMII6_TX_C_N NC_106 0.1 uF
C139 /SGMII6_RX_C_P NC_107 0.1 uF
C140 /SGMII6_RX_C_N NC_108 0.1 uF
C171 /A2V5_7 /GND 4.7 uF
C191 /A2V5_7 /GND 0.47 uF
C207 /A2V5_7 /GND 0.47 uF
C172 /A1V8_7 /GND 4.7 uF
C192 /A1V8_7 /GND 0.47 uF
C208 /A1V8_7 /GND 0.47 uF
C173 /A1V0_7 /GND 4.7 uF
C193 /A1V0_7 /GND 0.47 uF
C209 /A1V0_7 /GND 0.47 uF
C219 /A1V0_7 /GND 0.47 uF
C227 /A1V0_7 /GND 0.47 uF
C153 /1V8 /GND 0.47 uF
C163 /1V8 /GND 0.47 uF
C179 /1V8 /GND 0.47 uF
R89 /RX_CTRL_6 /1V8 5.76K
R104 /GND /RX_CTRL_6 2.49K
Q6 Net-_Q6-PadD1_ Net-_Q6-PadD2_ /LED_1_6 /LED_0_6 /GND /GND SSM6N58NU
R124 /LED1_6_N Net-_Q6-PadD1_ 470
Q8 Net-_Q8-PadD1_ Net-_Q8-PadD2_ /LED_1_7 /LED_0_7 /GND /GND SSM6N58NU
R141 /LED0_6_N Net-_Q6-PadD2_ 470
R135 /1V8 /LED_0_6 10K
R136 /LED_0_6 /GND 2.49K
L34 Net-_L34-Pad1_ /ETH6_AM_P /ETH6_AM_N Net-_L34-Pad4_ /ETH6_BM_P /ETH6_BM_N Net-_L34-Pad7_ /ETH6_CM_P /ETH6_CM_N Net-_L34-Pad10_ /ETH6_DM_N /ETH6_DM_P /ETH6_D_N /ETH6_D_P Net-_C183-Pad2_ /ETH6_C_N /ETH6_C_P Net-_C199-Pad2_ /ETH6_B_N /ETH6_B_P Net-_C215-Pad2_ /ETH6_A_N /ETH6_A_P Net-_C223-Pad2_ BOURNS_PT6120EL
C223 /GND Net-_C223-Pad2_ 0.1 uF
C215 /GND Net-_C215-Pad2_ 0.1 uF
C199 /GND Net-_C199-Pad2_ 0.1 uF
C183 /GND Net-_C183-Pad2_ 0.1 uF
R113 Net-_C231-Pad2_ Net-_L34-Pad1_ 75
R117 Net-_C231-Pad2_ Net-_L34-Pad4_ 75
R123 Net-_C231-Pad2_ Net-_L34-Pad7_ 75
R129 Net-_C231-Pad2_ Net-_L34-Pad10_ 75
C231 /SHIELD Net-_C231-Pad2_ 10 nF 2 kV
R90 /RX_D0_6 /1V8 5.76k
R105 /GND /RX_D0_6 2.49K
U15 /ETH7_A_P /ETH7_A_N /A2V5_7 /ETH7_B_P /ETH7_B_N /A1V0_7 /ETH7_C_P /ETH7_C_N /A2V5_7 /ETH7_D_P /ETH7_D_N Net-_R80-Pad2_ /A1V8_7 NC_109 /CLK_25MHZ_7 /MGMT_MDC /MGMT_MDIO NC_110 /1V8 /JTAG_TCK NC_111 /JTAG_TMS /JTAG_TDO_6 /A1V0_7 NC_112 NC_113 /SGMII7_TX_C_P /SGMII7_TX_C_N NC_114 /1V8 /A1V0_7 NC_115 /RX_D0_7 NC_116 /SGMII7_RX_C_P /SGMII7_RX_C_N NC_117 /RX_CTRL_7 NC_118 NC_119 /1V8 /A1V0_7 /PHY_RST_N Net-_R81-Pad2_ NC_120 /LED_1_7 /LED_0_7 /A1V8_7 /GND DP83867
L29 /A2V5_7 /2V5 600R
L31 /A1V0_7 /1V0 600R
L30 /A1V8_7 /1V8 600R
R80 /GND Net-_R80-Pad2_ 11K
R81 /1V8 Net-_R81-Pad2_ 10k
C141 /SGMII7_TX_C_P NC_121 0.1 uF
C142 /SGMII7_TX_C_N NC_122 0.1 uF
C143 /SGMII7_RX_C_P NC_123 0.1 uF
C144 /SGMII7_RX_C_N NC_124 0.1 uF
C158 /2V5 /GND 4.7 uF
C174 /A2V5_7 /GND 4.7 uF
C194 /A2V5_7 /GND 0.47 uF
C210 /A2V5_7 /GND 0.47 uF
C159 /1V8 /GND 4.7 uF
C175 /A1V8_7 /GND 4.7 uF
C195 /A1V8_7 /GND 0.47 uF
C211 /A1V8_7 /GND 0.47 uF
C160 /1V0 /GND 4.7 uF
C176 /A1V0_7 /GND 4.7 uF
C196 /A1V0_7 /GND 0.47 uF
C212 /A1V0_7 /GND 0.47 uF
C220 /A1V0_7 /GND 0.47 uF
C228 /A1V0_7 /GND 0.47 uF
C157 /1V8 /GND 0.47 uF
C164 /1V8 /GND 0.47 uF
C180 /1V8 /GND 0.47 uF
R93 /RX_CTRL_7 /1V8 5.76K
R108 /GND /RX_CTRL_7 2.49K
R126 /LED1_7_N Net-_Q8-PadD1_ 470
R142 /LED0_7_N Net-_Q8-PadD2_ 470
R137 /1V8 /LED_0_7 10K
R138 /LED_0_7 /GND 2.49K
L35 Net-_L35-Pad1_ /ETH7_AM_N /ETH7_AM_P Net-_L35-Pad4_ /ETH7_BM_P /ETH7_BM_N Net-_L35-Pad7_ /ETH7_CM_N /ETH7_CM_P Net-_L35-Pad10_ /ETH7_DM_N /ETH7_DM_P /ETH7_D_N /ETH7_D_P Net-_C184-Pad2_ /ETH7_C_N /ETH7_C_P Net-_C200-Pad2_ /ETH7_B_N /ETH7_B_P Net-_C216-Pad2_ /ETH7_A_N /ETH7_A_P Net-_C224-Pad2_ BOURNS_PT6120EL
C224 /GND Net-_C224-Pad2_ 0.1 uF
C216 /GND Net-_C216-Pad2_ 0.1 uF
C200 /GND Net-_C200-Pad2_ 0.1 uF
C184 /GND Net-_C184-Pad2_ 0.1 uF
R114 Net-_C232-Pad2_ Net-_L35-Pad1_ 75
R118 Net-_C232-Pad2_ Net-_L35-Pad4_ 75
R125 Net-_C232-Pad2_ Net-_L35-Pad7_ 75
R130 Net-_C232-Pad2_ Net-_L35-Pad10_ 75
C232 /SHIELD Net-_C232-Pad2_ 10 nF 2 kV
R94 /RX_D0_7 /1V8 2.49K
R83 /SGMII4_RX_C_P /1V8 10k
R84 /SGMII4_RX_C_N /1V8 10k
R98 /GND /SGMII4_RX_C_P 2.49K
R99 /GND /SGMII4_RX_C_N 2.49K
R95 /SGMII7_RX_C_P /1V8 10k
R96 /SGMII7_RX_C_N /1V8 10k
R109 /GND /SGMII7_RX_C_P 2.49K
R110 /GND /SGMII7_RX_C_N 2.49K
R91 /SGMII6_RX_C_P /1V8 10k
R92 /SGMII6_RX_C_N /1V8 10k
R106 /GND /SGMII6_RX_C_P 2.49K
R107 /GND /SGMII6_RX_C_N 2.49K
R87 /SGMII5_RX_C_P /1V8 10k
R88 /SGMII5_RX_C_N /1V8 10k
R102 /GND /SGMII5_RX_C_P 2.49K
R103 /GND /SGMII5_RX_C_N 2.49K
U16 /1V8 /GND Net-_R143-Pad2_ /1V8 DSC6101CI2A-025.0000
C233 /1V8 /GND 0.47 uF
R143 /CLK_25MHZ Net-_R143-Pad2_ 33
U17 Net-_R144-Pad2_ /GND /1V8 Net-_R145-Pad2_ /GND Net-_R146-Pad2_ Net-_R147-Pad2_ /1V8 Net-_R148-Pad2_ /GND Net-_R149-Pad2_ /1V8 Net-_R150-Pad2_ Net-_R151-Pad2_ /CLK_25MHZ /1V8 5PB1108CMG
C235 /1V8 /GND 0.47 uF
C234 /1V8 /GND 4.7 uF
C236 /1V8 /GND 0.47 uF
C237 /1V8 /GND 0.47 uF
R144 /CLK_25MHZ_0 Net-_R144-Pad2_ 33
R145 /CLK_25MHZ_1 Net-_R145-Pad2_ 33
R146 /CLK_25MHZ_2 Net-_R146-Pad2_ 33
R147 /CLK_25MHZ_3 Net-_R147-Pad2_ 33
R148 /CLK_25MHZ_4 Net-_R148-Pad2_ 33
R149 /CLK_25MHZ_5 Net-_R149-Pad2_ 33
R150 /CLK_25MHZ_6 Net-_R150-Pad2_ 33
R151 /CLK_25MHZ_7 Net-_R151-Pad2_ 33
C238 /SHIELD /GND TBD
C239 /SHIELD /GND TBD
R157 /SHIELD /GND TBD
R158 /SHIELD /GND TBD
.end
