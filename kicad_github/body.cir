.title KiCad schematic
C22 GND EP_VCC 100nF
C18 GND VCC 22uF
R14 GND /LED_EN 510K
U6 /LED_VOUT GND NC_01 /LED_EN VCC RT9715GGB, 0.7A
C28 GND /LED_VOUT 22uF
C19 GND VCC 10uF
R15 GND /EP_EN 510K
U7 EP_VCC GND NC_02 /EP_EN VCC RT9715GGB, 0.7A
C29 GND EP_VCC 10uF
C20 GND VCC 10uF
R16 GND /FAN_EN 510K
U8 /FAN_VOUT GND NC_03 /FAN_EN VCC RT9715GGB, 0.7A
C30 GND /FAN_VOUT 10uF
C21 GND VCC 10uF
R17 GND /SRV_EN 510K
U9 /SRV_VOUT GND NC_04 /SRV_EN VCC RT9715GGB, 0.7A
C31 GND /SRV_VOUT 10uF
U10 /UART_RX GND /EP_TXD /UART_TX EP_VCC /EP_RXD 74LVC2G07
R18 /EP_RXD EP_VCC 100K
C23 GND VCC 100nF
U11 /TXD1 GND /UART_RX /RXD1 VCC /UART_TX 74LVC2G07
R19 /RXD0 VCC 100K
R1 /~RESET0 VCC 10K
L1 VCC Net-_C3-Pad1_ 4.7uH
C3 Net-_C3-Pad1_ GND 100nF
C4 Net-_C4-Pad1_ GND 100nF
C2 VCC GND 100nF
C1 VCC GND 10uF
IC1 /FAN_PWM /HOST_INT /FAN_EN VCC GND /~STEP_SLP Net-_IC1-Pad7_ Net-_IC1-Pad8_ /STEP_DIR /STEP /SRV_CAM /SRV_FOOT /SRV_BRAKE /SRV_LOCK /MOSI0 /MISO0 /FRAME_STOP Net-_C3-Pad1_ /SRV_EN Net-_C4-Pad1_ GND /LED_DAT /LED_EN /LED_CLK /A2 /BUTTON /SDA0 /SCL0 /~RESET0 /RXD0 /TXD0 /FAN_TACHO ATMEGA328P(B)
U3 /~STEP_SLP Net-_R9-Pad2_ Net-_R10-Pad2_ /STEP_A1 GND /STEP_A2 /STEP_B2 GND /STEP_B1 GND /STEP /STEP_DIR GND GND Net-_R7-Pad1_ NC_05 Net-_C15-Pad2_ VCC VCC VCC GND Net-_U3-Pad22_ Net-_U3-Pad22_ Net-_U3-Pad22_ GND DRV8834-SSOP
C15 VCC Net-_C15-Pad2_ 10nF
R9 GND Net-_R9-Pad2_ 47K
R10 GND Net-_R10-Pad2_ 47K
C16 VCC GND 22uF
C17 VCC GND 4.7uF
R7 Net-_R7-Pad1_ VCC 47K
Y1 Net-_IC1-Pad7_ Net-_IC1-Pad8_ GND 16MHz
P5 /EP_RXD /UART_TX /EP_TXD /UART_RX /SRV_CAM /SRV_FOOT /SRV_BRAKE /SRV_LOCK /A2 /MOSI0 /MISO0 /FRAME_STOP /SRV_VOUT CONN1
P6 /CHG2_STAT /CHG2_CTL /BAT2_CTL /FAN_VOUT /TMP_INT /FAN_PWM /HOST_INT /FAN_TACHO /~RESET0 /SCL0 /SDA0 /BUTTON /LED_DAT /LED_CLK /LED_VOUT CONN2
P4 /STEP_A1 /STEP_A2 /STEP_B2 /STEP_B1 EP_VCC EP_VCC CONN3
P7 /PWR_INT /SDA1 /SCL1 /~RESET1 /BAT_INT /IR_TX /IR_RX /SDA2 /SCL2 CONN4
P2 GND VCC CONN_VCC
R4 /~RESET1 VCC 10K
L2 VCC Net-_C7-Pad1_ 4.7uH
C7 Net-_C7-Pad1_ GND 100nF
C8 Net-_C8-Pad1_ GND 100nF
C6 VCC GND 100nF
C5 VCC GND 10uF
IC2 /IR_TX /IR_RX /SDA2 VCC GND /SCL2 Net-_IC2-Pad7_ Net-_IC2-Pad8_ /BAT1_CTL /BAT1_STAT /CHG1_CTL /CHG1_STAT /BAT2_STAT /BAT2_CTL /CHG2_CTL /CHG2_STAT /TMP_INT Net-_C7-Pad1_ /VBAT2 Net-_C8-Pad1_ GND /VBAT /VCHG /VBAT1 /EP_EN /PWR_INT /SDA1 /SCL1 /~RESET1 /RXD1 /TXD1 Net-_C9-Pad1_ ATMEGA328P(B)
Y2 Net-_IC2-Pad7_ Net-_IC2-Pad8_ GND 16MHz
C9 Net-_C9-Pad1_ GND 1nF
R5 Net-_C9-Pad1_ /BAT_INT 1K
C10 GND VCC 100nF
U1 /UART_RX GND /TXD0 /UART_TX VCC /RXD0 74LVC2G07
R6 /RXD1 VCC 100K
SW1 GND /~RESET0 SW_PUSH_Small_Horizontal
SW2 GND /~RESET1 SW_PUSH_Small_Horizontal
C34 /BAT2+ GND 1uF
Q14 /BAT2_PATH2 /BAT2_PATH2 /BAT2_PATH2 Net-_Q12-Pad4_ Net-_Q14-Pad5_ Net-_Q14-Pad5_ NC_06 Net-_Q14-Pad5_ AON7423
Q12 /BAT2_PATH2 /BAT2_PATH2 /BAT2_PATH2 Net-_Q12-Pad4_ /BAT2+ /BAT2+ /BAT2+ /BAT2+ AON7423
U15 /BAT2+ GND /BAT2_CTL /BAT2_STAT Net-_Q12-Pad4_ /BAT LTC4412
C33 /BAT1+ GND 1uF
Q13 /BAT1_PATH2 /BAT1_PATH2 /BAT1_PATH2 Net-_Q11-Pad4_ Net-_Q13-Pad5_ Net-_Q13-Pad5_ NC_07 Net-_Q13-Pad5_ AON7423
Q11 /BAT1_PATH2 /BAT1_PATH2 /BAT1_PATH2 Net-_Q11-Pad4_ /BAT1+ /BAT1+ /BAT1+ /BAT1+ AON7423
U14 /BAT1+ GND /BAT1_CTL /BAT1_STAT Net-_Q11-Pad4_ /BAT LTC4412
C11 /CHARGE GND 100nF
Q4 /CHG2_PATH2 /CHG2_PATH2 /CHG2_PATH2 Net-_Q2-Pad4_ /BAT2+ /BAT2+ /BAT2+ /BAT2+ AON7423
Q2 /CHG2_PATH2 /CHG2_PATH2 /CHG2_PATH2 Net-_Q2-Pad4_ /CHARGE /CHARGE /CHARGE /CHARGE AON7423
U4 /CHARGE GND /CHG2_CTL /CHG2_STAT Net-_Q2-Pad4_ /BAT2+ LTC4412
Q3 /CHG1_PATH2 /CHG1_PATH2 /CHG1_PATH2 Net-_Q1-Pad4_ /BAT1+ /BAT1+ /BAT1+ /BAT1+ AON7423
Q1 /CHG1_PATH2 /CHG1_PATH2 /CHG1_PATH2 Net-_Q1-Pad4_ /CHARGE /CHARGE /CHARGE /CHARGE AON7423
U2 /CHARGE GND /CHG1_CTL /CHG1_STAT Net-_Q1-Pad4_ /BAT1+ LTC4412
C35 /VBAT1 GND 4.7nF
D2 /VBAT1 GND ESB5B5.0S
C37 /VBAT2 GND 4.7nF
R29 /VBAT2 /BAT2+ 10K
R28 /VBAT1 /BAT1+ 10K
R24 /VBAT1 GND 2M
R26 /VBAT2 GND 2M
D3 /VBAT2 GND ESB5B5.0S
R20 /COUT1 GND 5M
R8 /BAT1- Net-_Q7-Pad4_ 5M
Q9 GND GND GND /COUT1 /BAT1_PATH /BAT1_PATH /BAT1_PATH /BAT1_PATH CSD16327Q3/AON7524
Q7 /BAT1- /BAT1- /BAT1- Net-_Q7-Pad4_ /BAT1_PATH /BAT1_PATH /BAT1_PATH /BAT1_PATH AON7524/CSD16327Q3
R22 GND Net-_R22-Pad2_ 2.2K
C13 /BAT1- Net-_C13-Pad2_ 100nF
R12 Net-_Q5-Pad2_ Net-_C13-Pad2_ 330
U5 /COUT1 Net-_Q7-Pad4_ /BAT1- Net-_C13-Pad2_ Net-_R22-Pad2_ bq29700
Q5 /BAT1- Net-_Q5-Pad2_ /BAT1+ AO3419/AO3401
P8 /BAT1+ BAT1+
P9 /BAT1- BAT1-
R21 /COUT2 GND 5M
R11 /BAT2- Net-_Q8-Pad4_ 5M
Q10 GND GND GND /COUT2 /BAT2_PATH /BAT2_PATH /BAT2_PATH /BAT2_PATH CSD16327Q3/AON7524
Q8 /BAT2- /BAT2- /BAT2- Net-_Q8-Pad4_ /BAT2_PATH /BAT2_PATH /BAT2_PATH /BAT2_PATH AON7524/CSD16327Q3
R23 GND Net-_R23-Pad2_ 2.2K
C14 /BAT2- Net-_C14-Pad2_ 100nF
R13 Net-_Q6-Pad2_ Net-_C14-Pad2_ 330
U13 /COUT2 Net-_Q8-Pad4_ /BAT2- Net-_C14-Pad2_ Net-_R23-Pad2_ bq29700
Q6 /BAT2- Net-_Q6-Pad2_ /BAT2+ AO3419/AO3401
P10 /BAT2+ BAT2+
P11 /BAT2- BAT1-
P1 GND GND /BAT /BAT /BAT /BAT /CHARGE /CHARGE GND GND CONN5
C41 GND /CHARGE 100nF
R33 VCC /SCL1 10K
R32 VCC /SDA1 10K
C24 /VCHG GND 100pF
D1 /VCHG GND ESB5B5.0S
C25 /VBAT GND 100pF
R31 /VBAT /BAT 100
R30 /VCHG /CHARGE 100
R25 /VCHG GND 5M
R27 /VBAT GND 5M
D4 /VBAT GND ESB5B5.0S
R3 VCC /SCL0 10K
R2 VCC /SDA0 10K
.end
