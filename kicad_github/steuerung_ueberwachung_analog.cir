.title KiCad schematic
.include "/Users/frankkirschbaum/Entwicklung/KiCad-Spice-Library/Models/Diode/led.lib"
.include "/Users/frankkirschbaum/Entwicklung/KiCad-Spice-Library/Models/uncategorized/spice_complete/phil_fet.lib"
.include "/Users/frankkirschbaum/Entwicklung/KiCad-Spice-Library/Models/uncategorized/spice_complete/ti.lib"
D2 Net-_D2-Pad1_ Net-_D2-Pad2_ LED_GENERAL
R4 555_V+ Net-_D2-Pad2_ 1k5
U5 555_V- Net-_Q2-Pad3_ soll_aus Net-_R23-Pad2_ NC_01 555_V- NC_02 555_V+ NE555P
SW1 555_V- Net-_R23-Pad2_ SW_Push
SW2 555_V- Net-_Q2-Pad3_ SW_Push
D1 555_V- Net-_D1-Pad2_ LED_GENERAL
R3 soll_aus Net-_D1-Pad2_ 1k
J1 Net-_J1-Pad1_ 555_V- Conn_01x02_Male
R1 Net-_J1-Pad1_ Net-_J2-Pad3_ 10k
J2 Net-_J2-Pad1_ Net-_J13-Pad1_ Net-_J2-Pad3_ Conn_01x03_Male
R2 Net-_J14-Pad1_ Net-_J3-Pad3_ 90k
J3 555_V- Net-_J2-Pad1_ Net-_J3-Pad3_ Conn_01x03_Male
XQ1 555_V- soll_aus Net-_J13-Pad1_ 2N7000/PLP
J13 Net-_J13-Pad1_ 555_V- Conn_01x02_Male
XQ3 555_V- overtemp Net-_D2-Pad1_ 2N7000/PLP
XQ2 555_V- overtemp Net-_Q2-Pad3_ 2N7000/PLP
J11 Net-_100k1-Pad2_ 555_V- Conn_01x02_Male
J15 555_V- Net-_J15-Pad2_ Conn_01x02_Male
U6 Net-_R7-Pad2_ Net-_R7-Pad2_ Temp_Kuehlkoerper 555_V+ Net-_C42-Pad1_ Net-_R8-Pad2_ Net-_R8-Pad2_ Net-_R9-Pad2_ Net-_R9-Pad2_ Temp_Kuehlkoerper -12V Net-_C43-Pad1_ Net-_R10-Pad2_ Net-_R10-Pad2_ TL074
TP19 Net-_J15-Pad2_ TestPoint
R14 555_V+ Net-_J15-Pad2_ 18k
R12 Net-_J15-Pad2_ Net-_C46-Pad1_ 100k
TP20 overtemp TestPoint
R13 555_V+ overtemp 18k
R11 overtemp Net-_C44-Pad1_ 100k
XU1 overtemp Net-_C45-Pad1_ Net-_C44-Pad1_ LM393_TI
R6 555_V+ Net-_C43-Pad1_ 10k
R5 555_V+ Net-_C42-Pad1_ 10k
RV1 555_V- 555_V- Net-_C42-Pad1_ 100k
RV2 555_V- 555_V- Net-_C43-Pad1_ 100k
TP12 Net-_100k1-Pad2_ TestPoint
U7 555_V- Net-_C46-Pad1_ Net-_C47-Pad1_ Net-_J15-Pad2_ 555_V+ LM393
TP15 Net-_C44-Pad1_ TestPoint
R7 Net-_C44-Pad1_ Net-_R7-Pad2_ 10k
C42 Net-_C42-Pad1_ 555_V- 1u
C40 555_V+ 555_V- 100n
C43 Net-_C43-Pad1_ 555_V- 1u
C41 555_V+ 555_V- 100n
R8 Net-_C45-Pad1_ Net-_R8-Pad2_ 10k
C44 Net-_C44-Pad1_ 555_V- 100n
C47 Net-_C47-Pad1_ 555_V- 100n
TP16 Net-_C46-Pad1_ TestPoint
R9 Net-_C46-Pad1_ Net-_R9-Pad2_ 10k
R10 Net-_C47-Pad1_ Net-_R10-Pad2_ 10k
C46 Net-_C46-Pad1_ 555_V- 100n
TP18 Net-_C47-Pad1_ TestPoint
C45 Net-_C45-Pad1_ 555_V- 100n
TP17 Net-_C45-Pad1_ TestPoint
TP13 Net-_C42-Pad1_ TestPoint
TP14 Net-_C43-Pad1_ TestPoint
R23 555_V+ Net-_R23-Pad2_ 20k
R25 555_V+ Net-_Q2-Pad3_ 20k
C39 Temp_Kuehlkoerper 555_V- 100n
100k1 Temp_Kuehlkoerper Net-_100k1-Pad2_ 100k
J14 Net-_J14-Pad1_ 555_V- Conn_01x02_Male
J10 555_V+ 555_V- -12V Conn_01x03_Male
C50 555_V+ 555_V- 1n
C53 555_V+ 555_V- 100n
C55 555_V+ 555_V- 10u
J16 555_V+ Net-_C48-Pad2_ Conn_01x02_Male
C48 555_V+ Net-_C48-Pad2_ 1000u
C51 555_V+ Net-_C48-Pad2_ 10u
C57 555_V+ Net-_C48-Pad2_ 1n
C56 555_V+ Net-_C48-Pad2_ 100n
C54 555_V+ 555_V- 1u
C52 555_V+ 555_V- 10n
C49 555_V+ 555_V- 100p
H5 MountingHole
H6 MountingHole
H7 MountingHole
H8 MountingHole
C60 555_V+ 555_V- 100n
C58 555_V+ 555_V- 1n
C62 555_V+ 555_V- 10u
C61 555_V- -12V 100n
C59 555_V- -12V 1n
C63 555_V- -12V 10u
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
R18 Net-_C4-Pad1_ Net-_Q4-Pad1_ 1k
R26 Net-_C10-Pad1_ Net-_Q5-Pad3_ 33
R20 Net-_Q5-Pad1_ Net-_Q4-Pad3_ 10k
R19 Net-_Q5-Pad1_ Net-_J4-Pad2_ 15k
R15 -2V5 Net-_Q4-Pad3_ 7k4
J4 /Sollwert/+15V_ein Net-_J4-Pad2_ Conn_01x02_Male
R28 Net-_C10-Pad1_ /Sollwert/Ua_aus 220
R29 Net-_Q6-Pad2_ /Sollwert/Ua_aus 10
C3 NC_03 -2V5 100n
Q6 NC_04 Net-_Q6-Pad2_ Net-_Q6-Pad3_ BD139
HS1 Heatsink
C10 Net-_C10-Pad1_ -2V5 10u
J5 -2V5 -2V5 Net-_C10-Pad1_ Conn_01x03_Male
Q5 Net-_Q5-Pad1_ -2V5 Net-_Q5-Pad3_ BC850
Q4 Net-_Q4-Pad1_ /Sollwert/+15V_ein Net-_Q4-Pad3_ BC860
J6 Net-_D6-Pad1_ Net-_J6-Pad2_ Conn_01x02_Male
C5 Net-_C4-Pad1_ NC_05 3u3
C7 Net-_C4-Pad1_ NC_06 330n
C4 Net-_C4-Pad1_ NC_07 330u
D5 /Sollwert/Ua_aus NC_08 1N5818
R31 NC_09 Net-_Q7-Pad1_ 100
R30 /Sollwert/Ua_aus Net-_Q7-Pad3_ 4k7
D6 Net-_D6-Pad1_ /Sollwert/Ua_aus LED
Q8 Net-_Q7-Pad3_ Net-_Q7-Pad1_ Net-_J6-Pad2_ BC847
Q7 Net-_Q7-Pad1_ NC_10 Net-_Q7-Pad3_ BC847
D3 /Sollwert/+15V_ein /Sollwert/Ua_aus MRA4003T3G
D4 /Sollwert/Ua_aus Net-_C10-Pad1_ MRA4003T3G
U4 Net-_C10-Pad1_ /Sollwert/Ua_aus Net-_C4-Pad1_ LM317_TO-220
TP8 /Sollwert/Ua_aus TestPoint
TP2 -2V5 TestPoint
TP5 Net-_C4-Pad1_ TestPoint
TP7 Net-_C10-Pad1_ TestPoint
TP3 /Sollwert/+15V_ein TestPoint
TP1 Net-_J4-Pad2_ TestPoint
R21 Net-_J4-Pad2_ Net-_Q6-Pad3_ 1k
R17 /Sollwert/+15V_ein Net-_C4-Pad1_ 1R2
U2 NC_11 /Sollwert/+15V_ein NC_12 /Sollwert/GND NC_13 Net-_R22-Pad2_ NC_14 NC_15 ADR421ARMZ
R22 Net-_R22-Pad1_ Net-_R22-Pad2_ 10k
R27 -2V5 Net-_R22-Pad1_ 10k
R24 NC_16 Net-_R24-Pad2_ 5k
C11 V+ /Sollwert/GND 1u
C8 V+ /Sollwert/GND 10n
C9 /Sollwert/GND V- 10n
C2 /Sollwert/+15V_ein /Sollwert/GND 100n
C1 /Sollwert/+15V_ein /Sollwert/GND 1u
C6 -2V5 NC_17 10n
C12 /Sollwert/GND V- 1u
TP6 -2V5 TestPoint
TP4 Net-_R22-Pad2_ TestPoint
U3 NC_18 Net-_R22-Pad1_ Net-_R24-Pad2_ V- NC_19 -2V5 V+ NC_20 OP07
C15 /Sollwert/Ua_aus NC_21 150n
C14 /Sollwert/Ua_aus NC_22 15u
C13 /Sollwert/Ua_aus NC_23 1500u
R16 /Sollwert/+15V_ein Net-_C4-Pad1_ 1R2
.end
