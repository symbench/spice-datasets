.title KiCad schematic
U1 Net-_C2-Pad1_ Net-_R1-Pad2_ Net-_R2-Pad1_ GND /Power and glue/RES /Power and glue/RES VCC VCC TL7705B
R1 VCC Net-_R1-Pad2_ 22k
R3 /Power and glue/RES GND 3.3k
R2 Net-_R2-Pad1_ Net-_C1-Pad1_ 470
SW1 GND Net-_R1-Pad2_ RESET
C1 Net-_C1-Pad1_ GND 15uF
C2 Net-_C2-Pad1_ GND 0.1uF
SW2 GND /CPU, ROM and RAM/~NMI PANIC
Q1 /CPU, ROM and RAM/~NMI VCC GND DS1813
X1 NC_01 GND Net-_U2-Pad3_ VCC 16MHz
U2 VCC Net-_U2-Pad2_ Net-_U2-Pad3_ VCC /CPU, ROM and RAM/CLK Net-_U2-Pad2_ GND NC_02 NC_03 GND GND GND GND VCC 74HC74
J1 /Power and glue/POWER_IN GND GND NC_04 POWER_IN
F2 /Power and glue/POWER_IN Net-_C4-Pad1_ 1A
F1 VCC +5V 200mA
R4 VCC Net-_D1-Pad2_ 470
D1 GND Net-_D1-Pad2_ LED
C3 +5V GND 100uF
C4 Net-_C4-Pad1_ GND 100uF
SW3 Net-_C4-Pad1_ VCC NC_05 SPDT
H1 MountingHole
H2 MountingHole
H3 MountingHole
H4 MountingHole
H5 MountingHole
H6 MountingHole
C8 VCC GND 0.1uF
RN1 /Power and glue/RES /Power and glue/~PWR /CPU, ROM and RAM/~ABT /CPU, ROM and RAM/RDY VCC /CPU, ROM and RAM/BE /CPU, ROM and RAM/~NMI /CPU, ROM and RAM/~IRQ /Power and glue/~KS VCC 3.3k
U3 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 DS1511Y+
J2 VCC VCC /CPU, ROM and RAM/D0 /CPU, ROM and RAM/A0 /CPU, ROM and RAM/D1 /CPU, ROM and RAM/A1 /CPU, ROM and RAM/D2 /CPU, ROM and RAM/A2 /CPU, ROM and RAM/D3 /CPU, ROM and RAM/A3 /CPU, ROM and RAM/D4 /CPU, ROM and RAM/A4 /CPU, ROM and RAM/D5 /CPU, ROM and RAM/A5 /CPU, ROM and RAM/D6 /CPU, ROM and RAM/A6 /CPU, ROM and RAM/D7 /CPU, ROM and RAM/A7 NC_31 /CPU, ROM and RAM/A8 NC_32 /CPU, ROM and RAM/A9 NC_33 /CPU, ROM and RAM/A10 NC_34 /CPU, ROM and RAM/A11 NC_35 /CPU, ROM and RAM/A12 NC_36 /CPU, ROM and RAM/A13 NC_37 /CPU, ROM and RAM/A14 NC_38 /CPU, ROM and RAM/A15 NC_39 NC_40 NC_41 NC_42 GND GND Expansion Bus
C5 GND VCC 0.1uF
U5 /Power and glue/~PWR NC_43 NC_44 /Power and glue/RES /CPU, ROM and RAM/~IRQ /CPU, ROM and RAM/A4 /CPU, ROM and RAM/A3 /CPU, ROM and RAM/A2 /CPU, ROM and RAM/A1 /CPU, ROM and RAM/A0 /CPU, ROM and RAM/D0 /CPU, ROM and RAM/D1 /CPU, ROM and RAM/D2 GND /CPU, ROM and RAM/D3 /CPU, ROM and RAM/D4 /CPU, ROM and RAM/D5 /CPU, ROM and RAM/D6 /CPU, ROM and RAM/D7 NC_45 GND NC_46 GND /Power and glue/~KS NC_47 NC_48 NC_49 VCC DS1501W
U4 GND NC_50 /CPU, ROM and RAM/RDY /CPU, ROM and RAM/~ABT /CPU, ROM and RAM/~IRQ NC_51 /CPU, ROM and RAM/~NMI NC_52 VCC /CPU, ROM and RAM/A0 /CPU, ROM and RAM/A1 NC_53 /CPU, ROM and RAM/A2 /CPU, ROM and RAM/A3 /CPU, ROM and RAM/A4 /CPU, ROM and RAM/A5 /CPU, ROM and RAM/A6 /CPU, ROM and RAM/A7 /CPU, ROM and RAM/A8 /CPU, ROM and RAM/A9 /CPU, ROM and RAM/A10 /CPU, ROM and RAM/A11 GND GND /CPU, ROM and RAM/A12 /CPU, ROM and RAM/A13 /CPU, ROM and RAM/A14 /CPU, ROM and RAM/A15 /CPU, ROM and RAM/D7 /CPU, ROM and RAM/D6 /CPU, ROM and RAM/D5 /CPU, ROM and RAM/D4 /CPU, ROM and RAM/D3 /CPU, ROM and RAM/D2 /CPU, ROM and RAM/D1 /CPU, ROM and RAM/D0 VCC NC_54 NC_55 /CPU, ROM and RAM/BE /CPU, ROM and RAM/CLK NC_56 NC_57 /Power and glue/RES WD65C816S_PLCC44-65xx
C7 GND VCC 0.1uF
C6 VCC GND 0.1uF
U8 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 Net-_U8-Pad27_ Net-_U8-Pad10_ NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 Net-_U8-Pad27_ Net-_U8-Pad10_ NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 IS61C5128AL-10KLI
U9 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 Net-_U9-Pad27_ Net-_U9-Pad10_ NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 NC_111 NC_112 NC_113 Net-_U9-Pad27_ Net-_U9-Pad10_ NC_114 NC_115 NC_116 NC_117 NC_118 NC_119 NC_120 NC_121 IS61C5128AL-10KLI
U10 NC_122 NC_123 NC_124 NC_125 NC_126 NC_127 NC_128 NC_129 NC_130 NC_131 NC_132 NC_133 NC_134 NC_135 NC_136 NC_137 NC_138 NC_139 NC_140 NC_141 NC_142 NC_143 NC_144 NC_145 NC_146 NC_147 NC_148 NC_149 NC_150 NC_151 NC_152 NC_153 AT28HC256EPLCC32
U7 NC_154 NC_155 NC_156 Net-_U6-Pad4_ Net-_U6-Pad6_ NC_157 Net-_U6-Pad5_ Net-_U6-Pad18_ NC_158 NC_159 NC_160 NC_161 NC_162 NC_163 NC_164 NC_165 NC_166 NC_167 NC_168 NC_169 NC_170 Net-_U6-Pad21_ Net-_U6-Pad17_ NC_171 NC_172 NC_173 NC_174 NC_175 NC_176 NC_177 NC_178 NC_179 Net-_U6-Pad19_ NC_180 NC_181 NC_182 NC_183 Net-_U6-Pad22_ NC_184 NC_185 NC_186 NC_187 NC_188 NC_189 NC_190 NC_191 NC_192 NC_193 SC16C2550BIB48
U6 NC_194 NC_195 NC_196 Net-_U6-Pad4_ Net-_U6-Pad5_ Net-_U6-Pad6_ NC_197 NC_198 NC_199 NC_200 NC_201 NC_202 NC_203 NC_204 NC_205 NC_206 Net-_U6-Pad17_ Net-_U6-Pad18_ Net-_U6-Pad19_ NC_207 Net-_U6-Pad21_ Net-_U6-Pad22_ NC_208 NC_209 MAX238
.end
