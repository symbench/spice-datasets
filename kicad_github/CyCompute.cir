.title KiCad schematic
MD1 GND NC_01 NC_02 NC_03 NC_04 NC_05 GND GND GPIO02 NC_06 GPIO03 NC_07 GND GND GPIO04 NC_08 GPIO05 NC_09 GND GND GPIO06 NC_10 GPIO07 NC_11 GND GND GPIO08 GPIO28 GPIO09 GPIO29 GND GND GPIO10 GPIO30 GPIO11 GPIO31 GND GND +3V3 +3V3 +3V3 +3V3 GND GND GPIO12 GPIO32 GPIO13 GPIO33 GND GND GPIO14 GPIO34 GPIO15 GPIO35 GND GND GPIO16 GPIO36 GPIO17 GPIO37 GND GND GPIO18 GPIO38 GPIO19 GPIO39 GND GND GPIO20 NC_12 GPIO21 GPIO41 GND GND GPIO22 GPIO42 GPIO23 GPIO43 GND GND GPIO24 GPIO44 GPIO25 GPIO45 GND GND GPIO26 NC_13 GPIO27 NC_14 GND GND NC_15 NC_16 NC_17 NC_18 GND GND NC_19 NC_20 NC_21 NC_22 GND GND NC_23 NC_24 NC_25 NC_26 GND GND NC_27 NC_28 NC_29 NC_30 GND GND NC_31 NC_32 NC_33 NC_34 GND GND NC_35 NC_36 NC_37 NC_38 GND NC_39 NC_40 NC_41 NC_42 NC_43 GND GND CAM1_DP3 CAM0_DP0 CAM1_DN3 CAM0_DN0 GND GND CAM1_DP2 CAM0_CP CAM1_DN2 CAM0_CN GND GND CAM1_CP CAM0_DP1 CAM1_CN CAM0_DN1 GND GND CAM1_DP1 NC_44 CAM1_DN1 NC_45 GND NC_46 CAM1_DP0 NC_47 CAM1_DN0 NC_48 GND GND USBDP0 NC_49 USBDM0 NC_50 GND GND NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 GND GND +1V8 +1V8 +1V8 +1V8 GND GND +3V3 +3V3 +3V3 +3V3 +3V3 +3V3 GND GND +5V +5V +5V +5V Board_RPi_CM3lite_200pConnector
U2 USBDM2 USBDP2 USBDM3 USBDP3 VDD33A NC_61 NC_62 NC_63 NC_64 VDD33A VDD33IO Net-_C1-Pad1_ NC_65 PRTCTL2 VDD18CORE PRTCTL3 NC_66 NC_67 VDD33IO Net-_R19-Pad2_ Net-_R20-Pad2_ Net-_R21-Pad2_ NC_68 NC_69 NC_70 NC_71 VDD33IO +3V3 +3V3 +3V3 NC_72 +3V3 VDD33IO GND NC_73 NC_74 NC_75 VDD18CORE VDD33IO +3V3 Net-_R13-Pad1_ NC_76 NC_77 GND NC_78 VDD33IO NC_79 VDD18ETHPLL VDD33A Net-_R14-Pad1_ VDD33A Net-_C8-Pad2_ Net-_C7-Pad2_ VDD33A Net-_C10-Pad2_ Net-_C9-Pad2_ VDD33A USBDM0 USBDP0 Net-_C2-Pad1_ Net-_C3-Pad1_ VDD18USBPLL Net-_R12-Pad1_ VDD33A GND LAN9514
J1 GND GPIO30 GND GPIO29 GND GPIO28 GND GPIO27 RJ45
J8 +3V3 +5V GPIO02 +5V GPIO03 GND GPIO04 GPIO14 GND GPIO15 GPIO17 GPIO18 GPIO27 GND GPIO22 GPIO23 +3V3 GPIO24 GPIO10 GND GPIO09 GPIO25 GPIO11 GPIO08 GND GPIO07 NC_80 NC_81 GPIO05 GND GPIO06 GPIO12 GPIO13 GND GPIO19 GPIO16 GPIO26 GPIO20 GND GPIO21 Pi Std header
J2 GND GPIO34 GND GPIO33 GND GPIO32 GND GPIO31 RJ45
J3 GND GPIO38 GND GPIO37 GND GPIO36 GND GPIO35 RJ45
J4 GND GPIO43 GND GPIO42 GND GPIO41 GND GPIO39 RJ45
J5 NC_82 NC_83 NC_84 NC_85 NC_86 GPIO45 NC_87 GPIO44 RJ45
U1 GND GND Net-_R11-Pad1_ Net-_J9-Pad2_ Net-_J9-Pad1_ Net-_J10-Pad2_ Net-_J10-Pad1_ Net-_J11-Pad2_ Net-_J11-Pad1_ Net-_J12-Pad2_ Net-_J12-Pad1_ GND Net-_J13-Pad2_ Net-_J13-Pad1_ NC_88 NC_89 NC_90 NC_91 SX SY GND GPIO02 GPIO03 +3V3 TCA9548APWR
U3 NC_92 LX SX GND NC_93 SY LY +3V3 P82B715DR
J16 VCC_USB_EX1 USBDM2Out USBDP2Out GND Net-_J16-Pad5_ USB_A
J14 Net-_C10-Pad2_ Net-_C9-Pad2_ Net-_C8-Pad2_ NC_94 NC_95 Net-_C7-Pad2_ NC_96 NC_97 RJ45
L1 +3V3 VDD33A INDUCTOR 4.7uH
C11 VDD33A GND CAP100n
C15 VDD33A GND CAP100n
C19 VDD33A GND CAP100n
C24 VDD33A GND CAP100n
C27 VDD33A GND CAP100n
C31 VDD33A GND CAP100n
C32 VDD33A GND CAP100n
L2 +3V3 VDD33IO INDUCTOR 4.7uH
C12 VDD33IO GND CAP100n
C16 VDD33IO GND CAP100n
C20 VDD33IO GND CAP100n
C25 VDD33IO GND CAP100n
C28 VDD33IO GND CAP100n
C33 VDD18CORE GND CAP 100n
C30 VDD18CORE GND CAP 100n
C26 VDD18CORE GND CAP 4u7/6.3V
L5 VDD18USBPLL VDD18ETHPLL INDUCTOR 4.7 uH
C13 VDD18USBPLL GND CAP
C22 VDD18ETHPLL GND CAP
R12 Net-_R12-Pad1_ GND R 12K
R14 Net-_R14-Pad1_ GND R12k4
R13 Net-_R13-Pad1_ +3V3 10k
R9 +3V3 Net-_C1-Pad1_ R10k
C1 Net-_C1-Pad1_ GND CAP0.01uF 50V
D1 Net-_D1-Pad1_ +3V3 LED
D2 Net-_D2-Pad1_ +3V3 LED
D3 Net-_D3-Pad1_ +3V3 LED
R19 Net-_D1-Pad1_ Net-_R19-Pad2_ 330
R20 Net-_D2-Pad1_ Net-_R20-Pad2_ 330
R21 Net-_D3-Pad1_ Net-_R21-Pad2_ 330
Y1 Net-_C2-Pad1_ Net-_C3-Pad1_ Crystal 25M
R10 Net-_C3-Pad1_ Net-_C2-Pad1_ R 1M
C3 Net-_C3-Pad1_ GND CAP 33p
C2 Net-_C2-Pad1_ GND CAP 33p
R23 GND GNDS R 0
U4 USBDP2 GND USBDP2Out USBDM2Out NC_98 USBDM2 IP4234CZ6
U5 USBDP3 GND USBDP3Out USBDM3Out NC_99 USBDM3 IP4234CZ6
U7 PRTCTL2 PRTCTL2 PRTCTL3 PRTCTL3 VCC_USB_EX2 GND Net-_C23-Pad2_ VCC_USB_EX1 SP2526A-2EN-L
L6 +5V Net-_C23-Pad2_ 4.7uH
C23 GND Net-_C23-Pad2_ CAP1u/6.3v
C34 NC_100 GND 100u/10v
C29 GND NC_101 100u/10v
L7 Net-_J16-Pad5_ GND 4.7uH
J17 VCC_USB_EX2 USBDM3Out USBDP3Out GND Net-_J17-Pad5_ USB_A
L8 Net-_J17-Pad5_ GND 4.7uH
R15 Net-_C9-Pad2_ VDD33A 49.9
R18 Net-_C9-Pad2_ VDD33A 49.9
R16 VDD33A Net-_C8-Pad2_ 49.9
R17 VDD33A Net-_C8-Pad2_ 49.9
U6 +5V Net-_L4-Pad1_ GND FB1 +5V +5V Net-_L3-Pad1_ GND FB2 Net-_C4-Pad1_ GND PAM2306AYPKE
R22 +5V Net-_C4-Pad1_ 100k
C5 GND +5V 10u
C6 +5V GND 10u
C4 Net-_C4-Pad1_ GND 100n
L3 Net-_L3-Pad1_ +3V3 INDUCTOR
R24 +3V3 FB1 0
C14 +3V3 FB1 NF
R26 FB1 GND NF
C18 +3V3 GND 10u
L4 Net-_L4-Pad1_ +1V8 INDUCTOR
C17 +1V8 FB2 NF
R25 +1V8 FB2 0
R27 FB2 GND NF
C21 +1V8 GND 10u
C10 GND Net-_C10-Pad2_ 15pf
C9 GND Net-_C9-Pad2_ 15pf
C8 GND Net-_C8-Pad2_ 15pf
C7 GND Net-_C7-Pad2_ 15pf
R6 GPIO45 GND 100k
R5 GND GPIO44 100k
R7 GND GPIO28 100k
R8 GPIO29 GND 100k
J6 GND CAM0_DN0 CAM0_DP0 GND CAM0_DN1 CAM0_DP1 GND CAM0_CN CAM0_CP GND NC_102 NC_103 GND NC_104 NC_105 GND NC_106 NC_107 GND CAM0_SCL CAM0_SDA +3V3 CAM0
R1 +3V3 CAM0_SCL 1.8k
R3 +3V3 CAM0_SDA 1.8k
J7 GND CAM1_DN0 CAM1_DP0 GND CAM1_DN1 CAM1_DP1 GND CAM1_CN CAM1_CP GND CAM1_DN2 CAM1_DP2 GND CAM1_DN3 CAM1_DP3 GND NC_108 NC_109 GND CAM1_SCL CAM1_SDA +3V3 CAM1
R2 +3V3 CAM1_SCL 1.8k
R4 +3V3 CAM1_SDA 1.8k
J9 Net-_J9-Pad1_ Net-_J9-Pad2_ RJ11
J10 Net-_J10-Pad1_ Net-_J10-Pad2_ RJ11
J11 Net-_J11-Pad1_ Net-_J11-Pad2_ RJ11
J12 Net-_J12-Pad1_ Net-_J12-Pad2_ RJ11
J13 Net-_J13-Pad1_ Net-_J13-Pad2_ RJ11
J15 LY LX RJ11
R11 Net-_R11-Pad1_ +3V3 10k
J18 NC_110 +5V +3V3 GND Conn_01x04_Female
.end
