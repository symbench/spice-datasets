.title KiCad schematic
U3 NC_01 NC_02 NC_03 Net-_C2-Pad1_ Net-_C2-Pad1_ Net-_C21-Pad2_ Net-_C12-Pad1_ Net-_C9-Pad1_ Net-_C15-Pad1_ Net-_C15-Pad2_ GND +5V +5V GND Net-_C16-Pad2_ Net-_C16-Pad1_ Net-_C10-Pad1_ Net-_C13-Pad1_ Net-_C22-Pad2_ Net-_R2-Pad1_ GND Net-_C20-Pad2_ Net-_C11-Pad1_ Net-_C8-Pad1_ Net-_C14-Pad1_ Net-_C14-Pad2_ GND +5V +5V NC_04 NC_05 NC_06 TPS65261
C2 Net-_C2-Pad1_ GND 1u
R2 Net-_R2-Pad1_ GND 73.2K
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 47n
L1 Net-_C14-Pad2_ Net-_C20-Pad1_ 2.2u
C23 Net-_C20-Pad1_ GND 22u
R10 Net-_C20-Pad2_ GND 7K5
R5 Net-_C11-Pad1_ Net-_C17-Pad1_ 20K
C17 Net-_C17-Pad1_ GND 3.3n
C11 Net-_C11-Pad1_ GND 22p
C8 Net-_C8-Pad1_ GND 10n
R9 Net-_C20-Pad1_ Net-_C20-Pad2_ 15K
C3 +5V GND 10u
C20 Net-_C20-Pad1_ Net-_C20-Pad2_ 22p
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 47n
C24 Net-_C21-Pad1_ GND 22u
TP2 +2V5 TestPoint
R12 Net-_C21-Pad2_ GND 4.7K
R6 Net-_C12-Pad1_ Net-_C18-Pad1_ 20K
C18 Net-_C18-Pad1_ GND 3.3n
C12 Net-_C12-Pad1_ GND 22p
C9 Net-_C9-Pad1_ GND 10n
R11 Net-_C21-Pad1_ Net-_C21-Pad2_ 15K
C4 +5V GND 10u
C21 Net-_C21-Pad1_ Net-_C21-Pad2_ 22p
C16 Net-_C16-Pad1_ Net-_C16-Pad2_ 47n
C25 Net-_C22-Pad1_ GND 22u
TP3 +3V3 TestPoint
R14 Net-_C22-Pad2_ GND 3.3K
R7 Net-_C13-Pad1_ Net-_C19-Pad1_ 20K
C19 Net-_C19-Pad1_ GND 3.3n
C13 Net-_C13-Pad1_ GND 22p
C10 Net-_C10-Pad1_ GND 10n
R13 Net-_C22-Pad1_ Net-_C22-Pad2_ 15K
C5 +5V GND 10u
C22 Net-_C22-Pad1_ Net-_C22-Pad2_ 22p
L2 Net-_C15-Pad2_ Net-_C21-Pad1_ 2.2u
L3 Net-_C16-Pad2_ Net-_C22-Pad1_ 2.2u
R21 +1V8 Net-_C20-Pad1_ 0R
R17 +2V5 Net-_C21-Pad1_ 0R
R18 +3V3 Net-_C22-Pad1_ 0R
R3 GND Net-_R3-Pad2_ 4.7K
R1 +3V3 Net-_R1-Pad2_ 4.7K
C26 Net-_C20-Pad1_ GND 22u
C33 GND Net-_C33-Pad2_ 18p
FB1 VBUS Net-_FB1-Pad2_ Ferrite_Bead
C30 /TX1- Net-_C30-Pad2_ 100n
C31 /TX1+ Net-_C31-Pad2_ 100n
R31 Net-_R31-Pad1_ GND 1K6
R32 Net-_R32-Pad1_ +3V3 10K
R33 Net-_R33-Pad1_ +3V3 10K
R34 Net-_R34-Pad1_ +3V3 10K
C34 GND Net-_C34-Pad2_ 18p
R4 /JTAG_TCK GND 4k7
U5 /FLASH_CSn /FLASH_MISO /FLASH_WPn GND /FLASH_MOSI /FLASH_SCK /FLASH_HOLDn +3V3 IS25LP128F-JBLE
C39 +3V3 GND 100n
C40 +3V3 GND 100n
C37 VD10 GND 100n
C38 VD10 GND 4u7
C27 +3V3 GND 100n
C1 +3V3 GND 100n
U1 +3V3 GND NC_07 +3V3 DSC6001CI2A-016.0000T
R22 /INITn +3V3 10K
R20 FT_GPIO0 +3V3 10K
SW1 GND FT_GPIO0 SW_Push
TP1 FT_GPIO0 TestPoint
D1 Net-_D1-Pad1_ +3V3 LED
R8 Net-_D1-Pad1_ GND 2K
C47 +1V1 GND 10n
C44 +1V1 GND 100n
C52 +1V1 GND 10n
C50 +1V1 GND 100n
C56 +1V1 GND 10n
C54 +1V1 GND 100n
C48 +2V5 GND 10n
C45 +2V5 GND 100n
C49 +3V3 GND 10n
C46 +3V3 GND 100n
C53 +3V3 GND 10n
C51 +3V3 GND 100n
C57 +3V3 GND 10n
C55 +3V3 GND 100n
C59 +3V3 GND 10n
C58 +3V3 GND 100n
C61 +3V3 GND 10n
C60 +3V3 GND 100n
C63 +3V3 GND 10n
C62 +3V3 GND 100n
C65 +3V3 GND 10n
C64 +3V3 GND 100n
C67 +3V3 GND 10n
C66 +3V3 GND 100n
H1 GND
H2 GND
H3 GND
H4 GND
R23 Net-_R23-Pad1_ FT_GPIO1 0R
R24 Net-_R24-Pad1_ FT_GPIO0 0R
D3 Net-_D3-Pad1_ NC_08 LED
R15 Net-_D3-Pad1_ GND 2K
D4 Net-_D4-Pad1_ NC_09 LED
R26 Net-_D4-Pad1_ GND 2K
D5 Net-_D5-Pad1_ NC_10 LED
R30 Net-_D5-Pad1_ GND 2K
D6 Net-_D6-Pad1_ NC_11 LED
R59 Net-_D6-Pad1_ GND 2K
D7 Net-_D7-Pad1_ NC_12 LED
R60 Net-_D7-Pad1_ GND 2K
D8 Net-_D8-Pad1_ NC_13 LED
R61 Net-_D8-Pad1_ GND 2K
D9 Net-_D9-Pad1_ NC_14 LED
R62 Net-_D9-Pad1_ GND 2K
D10 Net-_D10-Pad1_ NC_15 LED
R63 Net-_D10-Pad1_ GND 2K
C6 +2V5 GND 100n
U4 GND VD10 VD10 /FT_BE_0 /FT_BE_1 NC_16 NC_17 /FT_TXE_N /FT_RXF_N Net-_R32-Pad1_ /FT_WR_N /FT_RD_N /FT_OE_N +3V3 Net-_R33-Pad1_ Net-_R34-Pad1_ Net-_R24-Pad1_ Net-_R23-Pad1_ NC_18 +3V3 Net-_C33-Pad2_ Net-_C34-Pad2_ /USB_D+ +3V3 /USB_D- GND Net-_R31-Pad1_ +3V3 GND VD10 /FT_TOD- /FT_TOD+ VD10 /FT_RID- /FT_RID+ GND Net-_R27-Pad1_ +3V3 VD10 /FT_DATA_0 /FT_DATA_1 /FT_DATA_2 /FT_DATA_3 /FT_DATA_4 /FT_DATA_5 /FT_DATA_6 /FT_DATA_7 VD10 +3V3 /FT_DATA_8 /FT_DATA_9 /FT_DATA_10 /FT_DATA_11 /FT_DATA_12 /FT_DATA_13 /FT_DATA_14 /FT_DATA_15 /FT_CLK +3V3 /FT_DATA_16 /FT_DATA_17 /FT_DATA_18 /FT_DATA_19 /FT_DATA_20 /FT_DATA_21 /FT_DATA_22 /FT_DATA_23 +3V3 /FT_DATA_24 /FT_DATA_25 /FT_DATA_26 /FT_DATA_27 /FT_DATA_28 /FT_DATA_29 /FT_DATA_30 /FT_DATA_31 GND FT601Q_FT602Q
U2 NC_19 NC_20 NC_21 /FT_DATA_16 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 /FT_DATA_24 NC_36 /FT_DATA_19 /FT_DATA_18 NC_37 NC_38 GND NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 GND NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 /FT_DATA_25 NC_52 NC_53 /FT_DATA_17 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 GND NC_66 /FT_DATA_26 NC_67 /FT_DATA_21 GND /FT_DATA_20 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 NC_82 /FT_DATA_27 /FT_DATA_31 /FT_DATA_22 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 /FT_DATA_30 NC_102 /FT_DATA_23 +2V5 GND GND +3V3 +3V3 +3V3 +3V3 GND GND +2V5 NC_103 NC_104 NC_105 NC_106 NC_107 NC_108 /FT_RXF_N NC_109 GND GND GND GND GND GND GND GND GND GND GND NC_110 GND NC_111 NC_112 NC_113 /FT_DATA_15 /FT_RD_N /FT_DATA_29 NC_114 NC_115 +3V3 +3V3 +1V1 +1V1 +1V1 +1V1 +1V1 +1V1 +3V3 +3V3 NC_116 NC_117 NC_118 GND NC_119 /FT_BE_0 GND /FT_CLK /FT_TXE_N /FT_BE_1 +3V3 GND +1V1 GND GND GND GND +1V1 GND +3V3 NC_120 NC_121 NC_122 NC_123 NC_124 /FT_WR_N /FT_OE_N /FT_DATA_14 NC_125 NC_126 GND GND +1V1 GND GND GND GND +1V1 GND GND NC_127 NC_128 NC_129 /FT_DATA_6 /FT_DATA_8 /FT_DATA_5 /FT_DATA_13 NC_130 +3V3 +3V3 +1V1 GND GND GND GND +1V1 +3V3 +3V3 NC_131 NC_132 NC_133 NC_134 NC_135 /FT_DATA_7 GND /FT_DATA_11 /FT_DATA_4 NC_136 +3V3 GND +1V1 GND GND GND GND +1V1 GND +3V3 GND NC_137 NC_138 NC_139 NC_140 /FT_DATA_9 /FT_DATA_12 /FT_DATA_10 NC_141 NC_142 GND GND +1V1 +1V1 +1V1 +1V1 +1V1 +1V1 GND GND NC_143 NC_144 NC_145 NC_146 NC_147 /FT_DATA_1 /FT_DATA_0 /FT_DATA_3 /FT_DATA_2 NC_148 +2V5 GND GND +3V3 +3V3 GND GND GND GND +2V5 NC_149 NC_150 NC_151 NC_152 NC_153 NC_154 /FLASH_CSn NC_155 Net-_R3-Pad2_ /JTAG_TDI NC_156 NC_157 NC_158 GND NC_159 NC_160 +3V3 +3V3 Net-_R1-Pad2_ /JTAG_TCK NC_161 NC_162 NC_163 NC_164 NC_165 NC_166 NC_167 NC_168 NC_169 NC_170 NC_171 NC_172 NC_173 NC_174 NC_175 NC_176 +3V3 /FLASH_SCK Net-_R3-Pad2_ /JTAG_TMS NC_177 GND GND GND GND GND GND GND GND NC_178 NC_179 NC_180 NC_181 NC_182 NC_183 NC_184 /FLASH_MISO /INITn /JTAG_TDO GND GND GND GND GND NC_185 NC_186 GND GND GND GND GND NC_187 NC_188 GND GND /FLASH_HOLDn /FLASH_MOSI FT_GPIO0 /HDTX0_D0CH0_P /HDTX0_D0CH0_N GND GND /HDTX0_D0CH1_P /HDTX0_D0CH1_N GND /HDTX0_D1CH0_P /HDTX0_D1CH0_N GND GND /HDTX0_D1CH1_P /HDTX0_D1CH1_N GND /REFCLK_D1_N /FLASH_WPn Net-_TP7-Pad1_ /HDRX0_D0CH0_P /HDRX0_D0CH0_N /HDRX0_D0CH1_P /HDRX0_D0CH1_N /REFCLK_D0_P /REFCLK_D0_N /HDRX0_D1CH0_P /HDRX0_D1CH0_N /HDRX0_D1CH1_P /HDRX0_D1CH1_N /REFCLK_D1_P LFE5UM-45F-6BG381C
R19 FT_GPIO1 +3V3 2K2
R25 FT_GPIO0 +3V3 2K2
C7 /TX2- Net-_C7-Pad2_ 100n
C28 /TX2+ Net-_C28-Pad2_ 100n
J3 /TX1- /TX1+ GND /RX1- /RX1+ /RX1+ /RX1- GND /TX1+ /TX1- PUSB3FR4Z
J4 /USB_D- /USB_D+ GND /CC2 /CC1 /CC1 /CC2 GND /USB_D+ /USB_D- PUSB3FR4Z
J5 /TX2+ /TX2- GND /RX2+ /RX2- /RX2- /RX2+ GND /TX2- /TX2+ PUSB3FR4Z
R16 VBUS Net-_R16-Pad2_ 910K
R27 Net-_R27-Pad1_ VBUS 910K
TP5 +1V8 TestPoint
C29 Net-_C29-Pad1_ /HDTX0_D0CH0_N 100n
C32 Net-_C32-Pad1_ /HDTX0_D0CH0_P 100n
C35 Net-_C35-Pad1_ /HDTX0_D0CH1_N 100n
C36 Net-_C36-Pad1_ /HDTX0_D0CH1_P 100n
C41 Net-_C41-Pad1_ /HDTX0_D1CH0_N 100n
C42 Net-_C42-Pad1_ /HDTX0_D1CH0_P 100n
C43 Net-_C43-Pad1_ /HDTX0_D1CH1_N 100n
C68 Net-_C68-Pad1_ /HDTX0_D1CH1_P 100n
R35 +3V3 /FLASH_WPn 10k
R29 +3V3 /FLASH_HOLDn 10k
R28 +3V3 /FLASH_CSn 4k7
R36 +3V3 /FLASH_SCK 1k1
R37 +3V3 /FLASH_MOSI 10k
R38 +3V3 /FLASH_MISO 10k
TP7 Net-_TP7-Pad1_ TestPoint
J1 GND +3V3 /JTAG_TDI /JTAG_TCK /JTAG_TMS /JTAG_TDO Conn_JTAG
J8 /HDTX0_D0CH0_P /HDTX0_D0CH0_N GND /HDRX0_D0CH0_P /HDRX0_D0CH0_N /HDRX0_D0CH0_N /HDRX0_D0CH0_P GND /HDTX0_D0CH0_N /HDTX0_D0CH0_P PUSB3FR4Z
J9 /HDTX0_D0CH1_P /HDTX0_D0CH1_N GND /HDRX0_D0CH1_P /HDRX0_D0CH1_N /HDRX0_D0CH1_N /HDRX0_D0CH1_P GND /HDTX0_D0CH1_N /HDTX0_D0CH1_P PUSB3FR4Z
J11 /HDTX0_D1CH0_P /HDTX0_D1CH0_N GND /HDRX0_D1CH0_P /HDRX0_D1CH0_N /HDRX0_D1CH0_N /HDRX0_D1CH0_P GND /HDTX0_D1CH0_N /HDTX0_D1CH0_P PUSB3FR4Z
J12 /HDTX0_D1CH1_P /HDTX0_D1CH1_N GND /HDRX0_D1CH1_P /HDRX0_D1CH1_N /HDRX0_D1CH1_N /HDRX0_D1CH1_P GND /HDTX0_D1CH1_N /HDTX0_D1CH1_P PUSB3FR4Z
J10 /REFCLK_D1_N /REFCLK_D1_P GND /REFCLK_D0_N /REFCLK_D0_P /REFCLK_D0_P /REFCLK_D0_N GND /REFCLK_D1_P /REFCLK_D1_N PUSB3FR4Z
J13 /USBC0_USB_P /USBC0_USB_N GND /USBC0_CC2 /USBC0_CC1 /USBC0_CC1 /USBC0_CC2 GND /USBC0_USB_N /USBC0_USB_P PUSB3FR4Z
J14 /USBC1_USB_P /USBC1_USB_N GND /USBC1_CC2 /USBC1_CC1 /USBC1_CC1 /USBC1_CC2 GND /USBC1_USB_N /USBC1_USB_P PUSB3FR4Z
J6 GND Net-_C32-Pad1_ Net-_C29-Pad1_ +5V /USBC0_CC1 /USBC0_USB_P /USBC0_USB_N /REFCLK_D0_P +5V /HDRX0_D0CH1_N /HDRX0_D0CH1_P GND GND Net-_C36-Pad1_ Net-_C35-Pad1_ +5V /USBC0_CC2 /USBC0_USB_P /USBC0_USB_N /REFCLK_D0_N +5V /HDRX0_D0CH0_N /HDRX0_D0CH0_P GND GND DX07S024JJ2
J7 GND Net-_C42-Pad1_ Net-_C41-Pad1_ +5V /USBC1_CC1 /USBC1_USB_P /USBC1_USB_N /REFCLK_D1_P +5V /HDRX0_D1CH1_N /HDRX0_D1CH1_P GND GND Net-_C68-Pad1_ Net-_C43-Pad1_ +5V /USBC1_CC2 /USBC1_USB_P /USBC1_USB_N /REFCLK_D1_N +5V /HDRX0_D1CH0_N /HDRX0_D1CH0_P GND GND DX07S024JJ2
J2 GND /TX1+ /TX1- Net-_FB1-Pad2_ /CC1 /USB_D+ /USB_D- NC_189 Net-_FB1-Pad2_ /RX2- /RX2+ GND GND /TX2+ /TX2- Net-_FB1-Pad2_ /CC2 /USB_D+ /USB_D- NC_190 Net-_FB1-Pad2_ /RX1- /RX1+ GND GND DX07S024JJ2
Y1 Net-_C33-Pad2_ NC_191 Net-_C34-Pad2_ NC_192 30MHz ±20ppm
U6 NC_193 NC_194 GND /FT_TOD+ /FT_TOD- VBUS /FT_RID- /FT_RID+ NC_195 NC_196 /CC1 /CC2 GND /RX1+ /RX1- Net-_C31-Pad2_ Net-_C30-Pad2_ /RX2- /RX2+ Net-_C7-Pad2_ Net-_C28-Pad2_ NC_197 Net-_R16-Pad2_ NC_198 GND PI5USB30213A
.end
