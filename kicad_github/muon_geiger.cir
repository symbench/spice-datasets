.title KiCad schematic
U1 Net-_C1-Pad1_ Net-_D5-Pad2_ Net-_C2-Pad1_ Net-_D6-Pad2_ Net-_C4-Pad1_ Net-_D7-Pad2_ GND Net-_D8-Pad2_ Net-_C5-Pad1_ Net-_D13-Pad2_ Net-_C11-Pad1_ Net-_D14-Pad2_ Net-_C12-Pad1_ +5V 74HC14
U2 Net-_C7-Pad1_ Net-_P9-Pad1_ Net-_C8-Pad1_ Net-_P10-Pad1_ Net-_C9-Pad1_ Net-_P11-Pad1_ GND Net-_P12-Pad1_ Net-_C10-Pad1_ Net-_P21-Pad1_ Net-_C17-Pad1_ Net-_P22-Pad1_ Net-_C18-Pad1_ +5V 74LS14
C9 Net-_C9-Pad1_ GND 4n7
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 10p
C6 GND +5V 100N
R3 Net-_C4-Pad2_ /400V 10M
R7 Net-_C4-Pad1_ +5V 100K
D3 Net-_C4-Pad1_ GND 5V3
D7 Net-_C9-Pad1_ Net-_D7-Pad2_ 1N914
P5 Net-_C4-Pad2_ CONN_01X01
P6 GND CONN_01X01
R11 GND Net-_C9-Pad1_ 220K
P11 Net-_P11-Pad1_ CONN_01X01
C10 Net-_C10-Pad1_ GND 4n7
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 10p
R4 Net-_C5-Pad2_ /400V 10M
R8 Net-_C5-Pad1_ +5V 100K
D4 Net-_C5-Pad1_ GND 5V3
D8 Net-_C10-Pad1_ Net-_D8-Pad2_ 1N914
P7 Net-_C5-Pad2_ CONN_01X01
P8 GND CONN_01X01
R12 GND Net-_C10-Pad1_ 220K
P12 Net-_P12-Pad1_ CONN_01X01
C7 Net-_C7-Pad1_ GND 4n7
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 10p
R1 Net-_C1-Pad2_ /400V 10M
R5 Net-_C1-Pad1_ +5V 100K
D1 Net-_C1-Pad1_ GND 5V3
D5 Net-_C7-Pad1_ Net-_D5-Pad2_ 1N914
P1 Net-_C1-Pad2_ CONN_01X01
P2 GND CONN_01X01
R9 GND Net-_C7-Pad1_ 220K
P9 Net-_P9-Pad1_ CONN_01X01
C8 Net-_C8-Pad1_ GND 4n7
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 10p
R2 Net-_C2-Pad2_ /400V 10M
R6 Net-_C2-Pad1_ +5V 100K
D2 Net-_C2-Pad1_ GND 5V3
D6 Net-_C8-Pad1_ Net-_D6-Pad2_ 1N914
P3 Net-_C2-Pad2_ CONN_01X01
P4 GND CONN_01X01
R10 GND Net-_C8-Pad1_ 220K
P10 Net-_P10-Pad1_ CONN_01X01
U3 Net-_C14-Pad1_ Net-_D15-Pad2_ Net-_C15-Pad1_ Net-_D16-Pad2_ GND +5V 74HC14
U4 Net-_C19-Pad1_ Net-_P23-Pad1_ Net-_C20-Pad1_ Net-_P24-Pad1_ GND +5V 74LS14
C19 Net-_C19-Pad1_ GND 4n7
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 10p
C16 GND +5V 100N
R15 Net-_C14-Pad2_ /400V 10M
R19 Net-_C14-Pad1_ +5V 100K
D11 Net-_C14-Pad1_ GND 5V3
D15 Net-_C19-Pad1_ Net-_D15-Pad2_ 1N914
P17 Net-_C14-Pad2_ CONN_01X01
P18 GND CONN_01X01
R23 GND Net-_C19-Pad1_ 220K
P23 Net-_P23-Pad1_ CONN_01X01
C20 Net-_C20-Pad1_ GND 4n7
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 10p
R16 Net-_C15-Pad2_ /400V 10M
R20 Net-_C15-Pad1_ +5V 100K
D12 Net-_C15-Pad1_ GND 5V3
D16 Net-_C20-Pad1_ Net-_D16-Pad2_ 1N914
P19 Net-_C15-Pad2_ CONN_01X01
P20 GND CONN_01X01
R24 GND Net-_C20-Pad1_ 220K
P24 Net-_P24-Pad1_ CONN_01X01
C17 Net-_C17-Pad1_ GND 4n7
C11 Net-_C11-Pad1_ Net-_C11-Pad2_ 10p
R13 Net-_C11-Pad2_ /400V 10M
R17 Net-_C11-Pad1_ +5V 100K
D9 Net-_C11-Pad1_ GND 5V3
D13 Net-_C17-Pad1_ Net-_D13-Pad2_ 1N914
P13 Net-_C11-Pad2_ CONN_01X01
P14 GND CONN_01X01
R21 GND Net-_C17-Pad1_ 220K
P21 Net-_P21-Pad1_ CONN_01X01
C18 Net-_C18-Pad1_ GND 4n7
C12 Net-_C12-Pad1_ Net-_C12-Pad2_ 10p
R14 Net-_C12-Pad2_ /400V 10M
R18 Net-_C12-Pad1_ +5V 100K
D10 Net-_C12-Pad1_ GND 5V3
D14 Net-_C18-Pad1_ Net-_D14-Pad2_ 1N914
P15 Net-_C12-Pad2_ CONN_01X01
P16 GND CONN_01X01
R22 GND Net-_C18-Pad1_ 220K
P22 Net-_P22-Pad1_ CONN_01X01
P25 NC_01 GND +5V NC_02 CONN_01X04
C3 /400V GND 1uF
P26 /400V CONN_01X01
.end
