.title KiCad schematic
U201 +15V GND 12Vreg LM7812_TO220
U204 GND -15V -12Vreg LM7912_TO220
C204 +15V GND 1000uF
C212 GND -15V 1000uF
C215 GND -15V 100n
C201 +15V GND 100n
U207 +7.5V GND 5Vreg LM78M05_TO252
U209 GND -15V -12Vreg MC79M12_TO252
U208 +15V GND 12Vreg LM78M12_TO252
D201 +15V 12Vreg 1N4001
D1 -12Vreg -15V 1N4001
F203 -12Vreg Net-_F203-Pad2_ 750mA
F201 12Vreg Net-_F201-Pad2_ 750mA
U205 NC_01 NC_02 Vin-15 DCDC+ XL6009 Module DCDC 19 to 30v
R205 DCDC+ Net-_D206-Pad2_ 10k
D206 Vin-15 Net-_D206-Pad2_ LED
U2 +7.5V GND 5Vreg LM7805_TO220
C5 +7.5V GND 1000uF
C8 +5V GND 1000uF
C4 +7.5V GND 100n
F1 5Vreg Net-_F1-Pad2_ 750mA
U1 VinGND Net-_R1-Pad1_ /GND-7V /7V Step Down Module +15 to 7v - MP2307
R1 Net-_R1-Pad1_ Vin+15 0R
D4 +7.5V 5Vreg 1N4001
U3 NC_03 VinGND Net-_C10-Pad1_ Vin-15 NC_04 Net-_R33-Pad2_ Vin+15 NC_05 TL071
R30 Vin+15 Net-_C10-Pad1_ 4k70
R31 Net-_C10-Pad1_ Vin-15 4k70
R33 Net-_Q4-Pad1_ Net-_R33-Pad2_ 330r
R32 Net-_C11-Pad1_ Vin+15 10r
R34 Net-_C12-Pad2_ Vin-15 10r
Q4 Net-_Q4-Pad1_ Net-_C11-Pad1_ VinGND TIP41
Q5 Net-_Q4-Pad1_ Net-_C12-Pad2_ VinGND TIP42
C9 Vin+15 Net-_C10-Pad1_ 220n
C10 Net-_C10-Pad1_ Vin-15 220n
C12 VinGND Net-_C12-Pad2_ 220n
C11 Net-_C11-Pad1_ VinGND 220n
C7 5Vreg GND 100n
Q2 Net-_C6-Pad1_ DCDC+ Vin+15 TIP41
R22 DCDC+ Net-_C6-Pad1_ 100r
C6 Net-_C6-Pad1_ Vin-15 1u
D207 Net-_D205-Pad2_ Vin-15 15v
D5 DCDC+ Vin+15 1N4001
D205 Net-_C6-Pad1_ Net-_D205-Pad2_ 15v
C3 /7V /GND-7V 1u
C1 Vin+15 VinGND 1u
C2 VinGND Vin-15 1u
R2 +15V Vin+15 0r25
R3 GND VinGND 0r25
R4 GND VinGND 0r25
R5 -15V Vin-15 0r25
R9 GND /GND-7V 0r25
R8 +7.5V /7V 0r25
C214 GND -12V 1000uF
C206 +12V GND 1000uF
Q1 /b4 Net-_JP201-Pad2_ I+12 MMBT2907A
R12 +12V Net-_F201-Pad2_ 1R1
R13 +12V Net-_F201-Pad2_ 1R1
R6 I+12 Net-_D3-Pad2_ 1k
D3 GND Net-_D3-Pad2_ RED
R14 /b4 +12V 5k6
R15 /b4 GND 100k
R10 +12V Net-_F201-Pad2_ 1R1
R11 +12V Net-_F201-Pad2_ 1R1
R7 I-12 Net-_D2-Pad1_ 1k
D2 Net-_D2-Pad1_ GND RED
Q205 /b5 Net-_JP202-Pad2_ I-12 MMBT2222A
R17 -12V /b5 4k7
R16 GND /b5 100k
R25 +5V Net-_F1-Pad2_ 1R1
R26 +5V Net-_F1-Pad2_ 1R1
R23 +5V Net-_F1-Pad2_ 1R1
R24 +5V Net-_F1-Pad2_ 1R1
R29 Net-_Q3-Pad1_ GND 100k
R28 Net-_Q3-Pad1_ +5V 15k
D6 GND Net-_D6-Pad2_ RED
R27 I+5 Net-_D6-Pad2_ 1k
Q3 Net-_Q3-Pad1_ 5Vreg I+5 MMBT2907A
JP201 12Vreg Net-_JP201-Pad2_ Net-_F201-Pad2_ SolderJumper_3_Bridged12
R20 -12V Net-_F203-Pad2_ 1R1
R21 -12V Net-_F203-Pad2_ 1R1
R18 -12V Net-_F203-Pad2_ 1R1
R19 -12V Net-_F203-Pad2_ 1R1
JP202 -12Vreg Net-_JP202-Pad2_ Net-_F203-Pad2_ SolderJumper_3_Bridged12
.end
