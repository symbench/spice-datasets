.title KiCad schematic
TP1 /P1_12 DBGEN
TP2 /P5_5 TRST
TP-J2 /U2_IO2_4 /EUT_5V /U2_IO2_6 /U2_IO2_5 /EUT_ADC0_0 /U2_IO2_7 /U2_IO3_1 /U2_IO3_0 /U2_IO3_3 /U2_IO3_2 /P6_0 /P4_7 /U2_IO3_5 /U2_IO3_4 /U2_IO3_7 /U2_IO3_6 /U2_IO4_1 /U2_IO4_0 /U2_IO4_3 /U2_IO4_2 /PF_4 /P0_1 /U2_IO4_4 /P0_0 /U2_IO4_5 /P3_0 /U2_IO4_6 /P7_2 /U2_IO4_7 /P3_6 /U2_IO0_0 /P3_3 /U2_IO0_2 /U2_IO0_1 /U2_IO0_4 /U2_IO0_3 /P7_1 /P3_7 /P2_3 /P2_4 EUT_NEIGHBOR2
TP-J1 GND /EUT_VCC /U1_IO4_7 /P3_1 /U1_IO4_6 /P3_2 /P1_0 /U1_IO4_5 /U1_IO4_4 /U1_IO4_3 /CLK0 /U1_IO4_2 /U1_IO4_1 /U1_IO4_0 /U1_IO3_7 /U1_IO3_6 /U1_IO3_5 /U1_IO3_4 /U1_IO3_3 /U1_IO3_2 /U1_IO3_1 /U1_IO3_0 /U1_IO2_7 /U1_IO2_6 /U1_IO2_5 /U1_IO2_4 /U1_IO2_3 /U1_IO2_2 /U1_IO2_1 /U1_IO2_0 /U1_IO1_7 /U1_IO1_6 /U1_IO1_5 /U1_IO1_4 /U1_IO1_3 /P4_7 /P1_20 /P1_19 /P1_3 /P1_4 EUT_NEIGHBOR1
TP9 /P1_15 SPIFI_CS
TP3 /U1_IO0_2 LED1
TP4 /U1_IO0_4 LED2
TP5 /U1_IO1_1 LED3
TP6 /U1_IO1_2 LED4
TP8 /U1_IO0_5 USB1_SENSE
TP10 /P2_0 USB1_EN
TP11 /U1_IO0_3 USB1_FAULT
TP12 /U1_IO0_6 USB1_ID
TP13 /U1_IO0_7 USB0_ID
TP-J7 /U1_IO0_1 /U1_IO0_0 /U2_IO2_3 /EUT_ADC0_5 /EUT_ADC0_2 /U2_IO2_2 /U2_IO2_1 /U2_IO2_0 /U2_IO1_7 /U2_IO1_6 /P1_18 /U2_IO1_5 /U2_IO1_4 /U2_IO1_3 /U2_IO1_2 /U2_IO1_1 /U2_IO1_0 /U2_IO0_7 /U2_IO0_6 /U2_IO0_5 EUT_BONUS_ROW
MH3 GND MOUNTING_HOLE
MH4 GND MOUNTING_HOLE
MH1 GND MOUNTING_HOLE
MH2 GND MOUNTING_HOLE
TP14 Net-_R6-Pad1_ USB0_VBUS
TP15 /U1_IO1_0 USB0_SENSE
TP16 /P5_7 TMS
TP17 /P5_6 TCK
TP18 /P1_14 TDO
TP19 /P5_3 TDI
TP-W1 Net-_R8-Pad1_ VBUS_BYPASS
U1 /I2C0_SDA /I2C0_SCL /U1_IO0_0 /U1_IO0_1 /U1_IO0_2 GND /U1_IO0_3 /U1_IO0_4 /U1_IO0_5 /U1_IO0_6 GND /U1_IO0_7 /U1_IO1_0 /U1_IO1_1 /U1_IO1_2 /U1_IO1_3 /U1_IO1_4 VCC /U1_IO1_5 /U1_IO1_6 /U1_IO1_7 /U1_IO2_0 GND /U1_IO2_1 /U1_IO2_2 /U1_IO2_3 GND VCC VCC /P1_17 /U1_IO2_4 /U1_IO2_5 /U1_IO2_6 GND /U1_IO2_7 /U1_IO3_0 /U1_IO3_1 /U1_IO3_2 GND /U1_IO3_3 /U1_IO3_4 /U1_IO3_5 /U1_IO3_6 /U1_IO3_7 /U1_IO4_0 VCC /U1_IO4_1 /U1_IO4_2 /U1_IO4_3 /U1_IO4_4 GND /U1_IO4_5 /U1_IO4_6 /U1_IO4_7 /P9_5 /P9_6 PCA9698
J2 GND +5V /P4_8 /P4_0 /ADC0_0 /P4_5 /P4_4 /P4_2 NC_01 /P4_6 /P4_7 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 /P2_4 /P2_3 /PF_4 /P3_2 /P7_2 /P3_1 /P7_1 /P3_0 NC_09 NC_10 NC_11 /P3_7 NC_12 /P3_3 NC_13 NC_14 NC_15 NC_16 NC_17 /P3_6 /I2C0_SDA /I2C0_SCL NEIGHBOR2
J1 GND VCC NC_18 /P0_0 NC_19 /P0_1 /P1_0 NC_20 NC_21 NC_22 /CLK0 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 /P5_3 NC_30 /P1_12 /P1_11 /P5_5 NC_31 /P1_14 /P1_13 /P5_6 /P1_15 /P5_7 /P1_16 /P1_18 /P1_17 /P9_5 /P9_6 /P2_0 /P6_0 /P1_20 /P1_19 /P1_4 /P1_3 NEIGHBOR1
MH7 NC_32 MOUNTING_HOLE
MH8 NC_33 MOUNTING_HOLE
MH5 NC_34 MOUNTING_HOLE
MH6 NC_35 MOUNTING_HOLE
TP7 Net-_R3-Pad1_ USB1_VBUS
U4 Net-_R1-Pad2_ /EUT_ADC0_0 /ADC0_0 /EUT_ADC0_5 /EUT_ADC0_2 /P4_5 GND GND /P4_8 /P4_0 /P4_4 Net-_R10-Pad2_ Net-_R8-Pad2_ Net-_R6-Pad2_ Net-_R3-Pad2_ VCC 74HC4051
C5 VCC GND 100nF
C4 VCC GND 100nF
C6 VCC GND 100nF
C7 VCC GND 100nF
C8 VCC GND 100nF
C9 VCC GND 100nF
C10 VCC GND 100nF
R1 /EUT_5V Net-_R1-Pad2_ 12.0k
R2 Net-_R1-Pad2_ GND 12.0k
R3 Net-_R3-Pad1_ Net-_R3-Pad2_ 12.0k
R4 Net-_R3-Pad2_ GND 12.0k
R6 Net-_R6-Pad1_ Net-_R6-Pad2_ 12.0k
R7 Net-_R6-Pad2_ GND 12.0k
R8 Net-_R8-Pad1_ Net-_R8-Pad2_ 12.0k
R9 Net-_R8-Pad2_ GND 12.0k
R10 /EUT_VCC Net-_R10-Pad2_ 12.0k
R11 Net-_R10-Pad2_ GND 12.0k
U3 +5V GND /P4_2 /P4_6 Net-_R12-Pad1_ /EUT_5V AP2553W6-7
C3 /EUT_5V GND 1µF
C2 +5V GND 1µF
R12 Net-_R12-Pad1_ GND 43.2k
R5 /P4_2 GND 12.0k
R13 VCC /P4_6 12.0k
R14 VCC /P9_6 12.0k
R15 VCC /P9_5 12.0k
R16 VCC /P1_17 12.0k
R19 VCC /P1_11 12.0k
R17 VCC /P1_16 12.0k
R18 VCC /P1_13 12.0k
U2 /I2C0_SDA /I2C0_SCL /U2_IO0_0 /U2_IO0_1 /U2_IO0_2 GND /U2_IO0_3 /U2_IO0_4 /U2_IO0_5 /U2_IO0_6 GND /U2_IO0_7 /U2_IO1_0 /U2_IO1_1 /U2_IO1_2 /U2_IO1_3 /U2_IO1_4 VCC /U2_IO1_5 /U2_IO1_6 /U2_IO1_7 /U2_IO2_0 GND /U2_IO2_1 /U2_IO2_2 /U2_IO2_3 VCC VCC VCC /P1_11 /U2_IO2_4 /U2_IO2_5 /U2_IO2_6 GND /U2_IO2_7 /U2_IO3_0 /U2_IO3_1 /U2_IO3_2 GND /U2_IO3_3 /U2_IO3_4 /U2_IO3_5 /U2_IO3_6 /U2_IO3_7 /U2_IO4_0 VCC /U2_IO4_1 /U2_IO4_2 /U2_IO4_3 /U2_IO4_4 GND /U2_IO4_5 /U2_IO4_6 /U2_IO4_7 /P1_13 /P1_16 PCA9698
MH11 NC_36 MOUNTING_HOLE
MH12 NC_37 MOUNTING_HOLE
MH9 NC_38 MOUNTING_HOLE
MH10 NC_39 MOUNTING_HOLE
MH13 NC_40 MOUNTING_HOLE
MH14 NC_41 MOUNTING_HOLE
.end
