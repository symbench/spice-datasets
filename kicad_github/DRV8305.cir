.title KiCad schematic
J2 Net-_J2-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ Net-_J2-Pad4_ Net-_J2-Pad5_ Net-_J2-Pad6_ PWM_IN
J3 Net-_J3-Pad1_ Net-_J3-Pad2_ Net-_J3-Pad3_ Net-_J3-Pad4_ SPI
J4 Net-_J4-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ Current
J1 Net-_J1-Pad1_ Net-_J1-Pad2_ Net-_J1-Pad3_ Net-_J1-Pad4_ DIO
C7 Net-_C7-Pad1_ SP_DC_BUS 1uF
C6 Net-_C6-Pad1_ SP_DC_BUS 1uF
C4 Net-_C4-Pad1_ SP_DC_BUS 1uF
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 0.047uF
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 0.047uF
C2 Net-_C2-Pad1_ SP_DC_BUS 1uF
R1 VPP Net-_R1-Pad2_ 100
C5 VPP Net-_C5-Pad2_ 2.2uF
J5 GH_A MOTOR_U SL_A GL_A SN_DC_BUS GL_A DRV_Phase_U
J6 GH_B MOTOR_V SL_B GL_B SN_DC_BUS GL_B DRV_Phase_V
J7 GH_C MOTOR_W SL_C GL_C SN_DC_BUS NC_01 DRV_Phase_W
U1 Net-_J1-Pad1_ Net-_J2-Pad1_ Net-_J2-Pad2_ Net-_J2-Pad3_ Net-_J2-Pad4_ Net-_J2-Pad5_ Net-_J2-Pad6_ Net-_J1-Pad2_ Net-_J3-Pad1_ Net-_J3-Pad2_ Net-_J3-Pad3_ Net-_J3-Pad4_ Net-_J1-Pad3_ SP_DC_BUS Net-_C7-Pad1_ Net-_J4-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ GL_C SN_DC_BUS GL_B SN_DC_BUS GL_A SN_DC_BUS GL_C SL_C MOTOR_W GH_C GH_B MOTOR_V SL_B GL_B GL_A SL_A MOTOR_U GH_A Net-_C6-Pad1_ Net-_C5-Pad2_ Net-_C3-Pad2_ Net-_C3-Pad1_ VPP Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_R1-Pad2_ SP_DC_BUS Net-_C4-Pad1_ Net-_J1-Pad4_ Net-_C2-Pad1_ DRV830x
R13 VCC Net-_R13-Pad2_ 10k
R14 Net-_D2-Pad1_ Net-_R13-Pad2_ 330R
D2 Net-_D2-Pad1_ VCC Red
J12 VCC SP_DC_BUS MCU_PWR
Q1 MOTOR_U MOTOR_U MOTOR_U GH_A VPP U_High
Q2 GL_A GL_A GL_A GL_A MOTOR_U U_Low
R2 GL_A SN_DC_BUS 0.5mR
C8 GL_A SN_DC_BUS 1000pF
C9 VPP SP_DC_BUS 1uF
Q3 MOTOR_V MOTOR_V MOTOR_V GH_B VPP U_High
Q4 GL_B GL_B GL_B GL_B MOTOR_V U_Low
R3 GL_B SN_DC_BUS 0.5mR
C10 GL_B SN_DC_BUS 1000pF
C11 VPP SP_DC_BUS 1uF
Q5 MOTOR_W MOTOR_W MOTOR_W GH_C VPP U_High
Q6 GL_C GL_C GL_C GL_C MOTOR_W U_Low
R4 GL_C SN_DC_BUS 0.5mR
C12 GL_C SN_DC_BUS 1000pF
C13 VPP SP_DC_BUS 1uF
J8 Net-_D3-Pad2_ SP_DC_BUS MotorPower
C14 VPP SP_DC_BUS 470uF
C15 VPP SP_DC_BUS 470uF
C16 VPP SP_DC_BUS 0.1uF
C17 VPP SP_DC_BUS 0.1uF
R5 VPP PVDD_Sense SenseUpper
R6 PVDD_Sense SP_DC_BUS SenseLower
D1 VPP PVDD_Sense 1N5817
C18 PVDD_Sense SP_DC_BUS 0.1uF
R20 MOTOR_U Vsen_A 62k
R31 Vsen_B SP_DC_BUS 4k99
R30 MOTOR_V Vsen_B 62k
R41 Vsen_C SP_DC_BUS 4k99
R40 MOTOR_W Vsen_C 62k
R21 Vsen_A SP_DC_BUS 4k99
J14 MOTOR_U MOTOR_V MOTOR_W Motor
U4 SP_DC_BUS VCC VPP VCC AP111733
C22 VPP SP_DC_BUS 0.1uF
C25 VCC SP_DC_BUS 0.1uF
C23 VPP SP_DC_BUS 10uF
C24 VCC SP_DC_BUS 10uF
J15 VCC SP_DC_BUS PWR_Out
D3 VPP Net-_D3-Pad2_ 2N4001
U3 Vsen_A SP_DC_BUS Vsen_B Vsen_C VCC PVDD_Sense CSRV065V0P
J13 Vsen_A Vsen_B Vsen_C PVDD_Sense MotorVSense
R15 SN_DC_BUS SP_DC_BUS DC_Link
C26 SN_DC_BUS SP_DC_BUS 1000pF
U2 Net-_J9-Pad2_ Net-_C19-Pad1_ Net-_J9-Pad3_ Net-_J9-Pad5_ Net-_C20-Pad1_ Net-_J9-Pad4_ Net-_C21-Pad1_ VCC SN74LVC3G07MDCUREP
J11 Net-_C21-Pad1_ Net-_C20-Pad1_ Net-_C19-Pad1_ HALL_Sensor
J9 VCC Net-_J9-Pad2_ Net-_J9-Pad3_ Net-_J9-Pad4_ Net-_J9-Pad5_ MCU_HALL
J10 Net-_J10-Pad1_ SP_DC_BUS HALL_PWR
R9 VCC Net-_J9-Pad4_ 10k
R11 Net-_J10-Pad1_ Net-_C20-Pad1_ 1k
R12 Net-_J10-Pad1_ Net-_C19-Pad1_ 1k
R10 Net-_J10-Pad1_ Net-_C21-Pad1_ 1k
R8 VCC Net-_J9-Pad3_ 10k
R7 VCC Net-_J9-Pad2_ 10k
C19 Net-_C19-Pad1_ SP_DC_BUS 1000pF
C20 Net-_C20-Pad1_ SP_DC_BUS 1000pF
C21 Net-_C21-Pad1_ SP_DC_BUS 1000pF
.end
