.title KiCad schematic
C45 NC_01 Net-_C45-Pad2_ C
C47 NC_02 Net-_C45-Pad2_ C
C46 Net-_C46-Pad1_ NC_03 C
C48 Net-_C46-Pad1_ NC_04 C
J18 Net-_C45-Pad2_ NC_05 Net-_J18-Pad3_ Net-_J18-Pad3_ NC_06 Net-_C46-Pad1_ InConnector
J19 NC_07 NC_08 Net-_J19-Pad3_ Net-_J19-Pad3_ NC_09 NC_10 OutConnector
U11 NC_11 Net-_R115-Pad1_ Net-_R113-Pad2_ NC_12 NC_13 Net-_J19-Pad3_ NC_14 NC_15 OPA333xxD
R115 Net-_R115-Pad1_ Net-_J19-Pad3_ R
R114 NC_16 Net-_R113-Pad2_ R
R112 Net-_R111-Pad2_ Net-_J19-Pad3_ R
R113 Net-_R111-Pad2_ Net-_R113-Pad2_ R
R111 Net-_J18-Pad3_ Net-_R111-Pad2_ R
R116 NC_17 Net-_R115-Pad1_ R
C49 NC_18 Net-_C49-Pad2_ C
C51 NC_19 Net-_C49-Pad2_ C
C50 Net-_C50-Pad1_ NC_20 C
C52 Net-_C50-Pad1_ NC_21 C
J20 Net-_C49-Pad2_ NC_22 Net-_J20-Pad3_ Net-_J20-Pad3_ NC_23 Net-_C50-Pad1_ InConnector
J21 NC_24 NC_25 Net-_J21-Pad3_ Net-_J21-Pad3_ NC_26 NC_27 OutConnector
R120 NC_28 Net-_R119-Pad2_ R
R118 Net-_R117-Pad2_ Net-_R118-Pad2_ R
R119 Net-_R117-Pad2_ Net-_R119-Pad2_ R
R117 Net-_J20-Pad3_ Net-_R117-Pad2_ R
U12 Net-_R118-Pad2_ Net-_R121-Pad1_ Net-_R119-Pad2_ NC_29 Net-_R125-Pad2_ Net-_R127-Pad1_ Net-_J21-Pad3_ NC_30 ADA4807-2ARM
R126 NC_31 Net-_R125-Pad2_ R
R124 Net-_R123-Pad2_ Net-_J21-Pad3_ R
R125 Net-_R123-Pad2_ Net-_R125-Pad2_ R
R123 Net-_R118-Pad2_ Net-_R123-Pad2_ R
R121 Net-_R121-Pad1_ Net-_R118-Pad2_ R
R122 NC_32 Net-_R121-Pad1_ R
R127 Net-_R127-Pad1_ Net-_J21-Pad3_ R
R128 NC_33 Net-_R127-Pad1_ R
C57 NC_34 Net-_C57-Pad2_ C
C59 NC_35 Net-_C57-Pad2_ C
C58 Net-_C58-Pad1_ NC_36 C
C60 Net-_C58-Pad1_ NC_37 C
J24 Net-_C57-Pad2_ NC_38 Net-_J24-Pad3_ Net-_J24-Pad4_ NC_39 Net-_C58-Pad1_ InConnector
J25 Net-_C61-Pad2_ NC_40 Net-_J25-Pad3_ Net-_J25-Pad4_ NC_41 Net-_C62-Pad1_ OutConnector
U14 NC_42 Net-_R161-Pad1_ Net-_R156-Pad2_ NC_43 NC_44 Net-_J25-Pad3_ NC_45 NC_46 OPA333xxD
R161 Net-_R161-Pad1_ Net-_J25-Pad3_ R
R159 NC_47 Net-_R156-Pad2_ R
R155 Net-_R153-Pad2_ Net-_J25-Pad3_ R
R156 Net-_R153-Pad2_ Net-_R156-Pad2_ R
R153 Net-_J24-Pad3_ Net-_R153-Pad2_ R
R162 NC_48 Net-_R161-Pad1_ R
U15 NC_49 Net-_R163-Pad1_ Net-_R158-Pad2_ NC_50 NC_51 Net-_J25-Pad4_ NC_52 NC_53 OPA333xxD
R163 Net-_R163-Pad1_ Net-_J25-Pad4_ R
R160 NC_54 Net-_R158-Pad2_ R
R157 Net-_R154-Pad2_ Net-_J25-Pad4_ R
R158 Net-_R154-Pad2_ Net-_R158-Pad2_ R
R154 Net-_J24-Pad4_ Net-_R154-Pad2_ R
R164 NC_55 Net-_R163-Pad1_ R
C61 NC_56 Net-_C61-Pad2_ C
C63 NC_57 Net-_C61-Pad2_ C
C62 Net-_C62-Pad1_ NC_58 C
C64 Net-_C62-Pad1_ NC_59 C
C65 NC_60 Net-_C65-Pad2_ C
C67 NC_61 Net-_C65-Pad2_ C
C66 Net-_C66-Pad1_ NC_62 C
C68 Net-_C66-Pad1_ NC_63 C
J26 Net-_C65-Pad2_ NC_64 Net-_J26-Pad3_ Net-_J26-Pad4_ NC_65 Net-_C66-Pad1_ InConnector
J27 Net-_C69-Pad2_ NC_66 Net-_J27-Pad3_ Net-_J27-Pad4_ NC_67 Net-_C70-Pad1_ OutConnector
R171 NC_68 Net-_R168-Pad2_ R
R167 Net-_R165-Pad2_ Net-_R167-Pad2_ R
R168 Net-_R165-Pad2_ Net-_R168-Pad2_ R
R165 Net-_J26-Pad3_ Net-_R165-Pad2_ R
U16 Net-_J27-Pad3_ Net-_R185-Pad1_ Net-_R180-Pad2_ NC_69 Net-_R168-Pad2_ Net-_R173-Pad1_ Net-_R167-Pad2_ NC_70 ADA4807-2ARM
R183 NC_71 Net-_R180-Pad2_ R
R179 Net-_R177-Pad2_ Net-_J27-Pad3_ R
R180 Net-_R177-Pad2_ Net-_R180-Pad2_ R
R177 Net-_R167-Pad2_ Net-_R177-Pad2_ R
R173 Net-_R173-Pad1_ Net-_R167-Pad2_ R
R174 NC_72 Net-_R173-Pad1_ R
R185 Net-_R185-Pad1_ Net-_J27-Pad3_ R
R186 NC_73 Net-_R185-Pad1_ R
C69 NC_74 Net-_C69-Pad2_ C
C71 NC_75 Net-_C69-Pad2_ C
C70 Net-_C70-Pad1_ NC_76 C
C72 Net-_C70-Pad1_ NC_77 C
R172 NC_78 Net-_R170-Pad2_ R
R169 Net-_R166-Pad2_ Net-_R169-Pad2_ R
R170 Net-_R166-Pad2_ Net-_R170-Pad2_ R
R166 Net-_J26-Pad4_ Net-_R166-Pad2_ R
U17 Net-_J27-Pad4_ Net-_R187-Pad1_ Net-_R182-Pad2_ NC_79 Net-_R170-Pad2_ Net-_R175-Pad1_ Net-_R169-Pad2_ NC_80 ADA4807-2ARM
R184 NC_81 Net-_R182-Pad2_ R
R181 Net-_R178-Pad2_ Net-_J27-Pad4_ R
R182 Net-_R178-Pad2_ Net-_R182-Pad2_ R
R178 Net-_R169-Pad2_ Net-_R178-Pad2_ R
R175 Net-_R175-Pad1_ Net-_R169-Pad2_ R
R176 NC_82 Net-_R175-Pad1_ R
R187 Net-_R187-Pad1_ Net-_J27-Pad4_ R
R188 NC_83 Net-_R187-Pad1_ R
.end
