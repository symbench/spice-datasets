.title KiCad schematic
C4 +3V3 chasis 104
C5 +3V3 chasis 104
C6 +3V3 chasis 104
C7 +3V3 chasis 104
C8 +3V3 chasis 104
C3 +3V3 chasis 104
C2 +3V3 chasis 104
C1 +3V3 chasis 104
SW2 chasis chasis NC_01 /Interlock/SW2_1 /Interlock/SW2_2 /Interlock/SW2_3 /Interlock/SW2_4 /Interlock/SW2_5 /Interlock/SW2_6 chasis SRBV170501
SW4 /Interlock/REMOTE chasis REMOTE
SW3 /Interlock/LOAD chasis LOAD
J1 /Interlock/TCK chasis /Interlock/TDO +3V3 /Interlock/TMS NC_02 +3V3 NC_03 /Interlock/TDI chasis Blaster JTAG
SEG1 Net-_R5-Pad1_ Net-_R4-Pad1_ Net-_Q1-Pad3_ Net-_R3-Pad1_ Net-_R8-Pad1_ Net-_R2-Pad1_ Net-_R1-Pad1_ Net-_Q1-Pad3_ Net-_R6-Pad1_ Net-_R7-Pad1_ 0.56'' BLUE CA
R1 Net-_R1-Pad1_ /Interlock/SEG1_A 33
R2 Net-_R2-Pad1_ /Interlock/SEG1_B 33
R3 Net-_R3-Pad1_ /Interlock/SEG1_C 33
R4 Net-_R4-Pad1_ /Interlock/SEG1_D 33
R5 Net-_R5-Pad1_ /Interlock/SEG1_E 33
R6 Net-_R6-Pad1_ /Interlock/SEG1_F 33
R7 Net-_R7-Pad1_ /Interlock/SEG1_G 33
R8 Net-_R8-Pad1_ /Interlock/SEG1_DP 33
R9 Net-_R9-Pad1_ /Interlock/SEG2_A 33
R11 Net-_R11-Pad1_ /Interlock/SEG2_B 33
R12 Net-_R12-Pad1_ /Interlock/SEG2_C 33
R13 Net-_R13-Pad1_ /Interlock/SEG2_D 33
R14 Net-_R14-Pad1_ /Interlock/SEG2_E 33
R15 Net-_R15-Pad1_ /Interlock/SEG2_F 33
R16 Net-_R16-Pad1_ /Interlock/SEG2_G 33
R17 Net-_R17-Pad1_ /Interlock/SEG2_DP 33
Q1 Net-_Q1-Pad1_ +3V3 Net-_Q1-Pad3_ 8550
Q2 Net-_Q2-Pad1_ +3V3 Net-_Q2-Pad3_ 8550
R10 Net-_Q1-Pad1_ /Interlock/SEG1 1K
J3 +12V +3V3 Net-_J3-Pad3_ Net-_J3-Pad4_ Net-_J3-Pad5_ Net-_J3-Pad6_ Net-_J3-Pad7_ Net-_J3-Pad8_ Conn_01x08
J4 Net-_J4-Pad1_ Net-_J4-Pad2_ Net-_J4-Pad3_ Net-_J4-Pad4_ Net-_J4-Pad5_ Net-_J4-Pad6_ chasis chasis Conn_01x08
D1 Net-_D1-Pad1_ +3V3 Remote
R25 Net-_D1-Pad1_ /Interlock/REMOTE 4.7K
Q8 Net-_Q8-Pad1_ chasis Net-_Q8-Pad3_ 8050
Q7 Net-_Q7-Pad1_ chasis Net-_Q7-Pad3_ 8050
Q6 Net-_Q6-Pad1_ chasis Net-_Q6-Pad3_ 8050
Q5 Net-_Q5-Pad1_ chasis Net-_Q5-Pad3_ 8050
Q4 Net-_Q4-Pad1_ chasis Net-_Q4-Pad3_ 8050
Q3 Net-_Q3-Pad1_ chasis Net-_Q3-Pad3_ 8050
Q14 Net-_Q14-Pad1_ chasis Net-_Q14-Pad3_ 8050
Q13 Net-_Q13-Pad1_ chasis Net-_Q13-Pad3_ 8050
Q12 Net-_Q12-Pad1_ chasis Net-_Q12-Pad3_ 8050
Q11 Net-_Q11-Pad1_ chasis Net-_Q11-Pad3_ 8050
Q10 Net-_Q10-Pad1_ chasis Net-_Q10-Pad3_ 8050
Q9 Net-_Q9-Pad1_ chasis Net-_Q9-Pad3_ 8050
Q15 Net-_Q15-Pad1_ +12V Net-_J3-Pad3_ 8550
R26 Net-_Q3-Pad3_ Net-_Q15-Pad1_ 4.7K
Q16 Net-_Q16-Pad1_ +12V Net-_J3-Pad4_ 8550
Q17 Net-_Q17-Pad1_ +12V Net-_J3-Pad5_ 8550
Q18 Net-_Q18-Pad1_ +12V Net-_J3-Pad6_ 8550
Q19 Net-_Q19-Pad1_ +12V Net-_J3-Pad7_ 8550
Q20 Net-_Q20-Pad1_ +12V Net-_J3-Pad8_ 8550
Q21 Net-_Q21-Pad1_ +12V Net-_J4-Pad1_ 8550
Q22 Net-_Q22-Pad1_ +12V Net-_J4-Pad2_ 8550
Q23 Net-_Q23-Pad1_ +12V Net-_J4-Pad3_ 8550
Q24 Net-_Q24-Pad1_ +12V Net-_J4-Pad4_ 8550
Q25 Net-_Q25-Pad1_ +12V Net-_J4-Pad5_ 8550
Q26 Net-_Q26-Pad1_ +12V Net-_J4-Pad6_ 8550
R27 Net-_Q4-Pad3_ Net-_Q16-Pad1_ 4.7K
R28 Net-_Q5-Pad3_ Net-_Q17-Pad1_ 4.7K
R29 Net-_Q6-Pad3_ Net-_Q18-Pad1_ 4.7K
R30 Net-_Q7-Pad3_ Net-_Q19-Pad1_ 4.7K
R31 Net-_Q8-Pad3_ Net-_Q20-Pad1_ 4.7K
R32 Net-_Q9-Pad3_ Net-_Q21-Pad1_ 4.7K
R33 Net-_Q10-Pad3_ Net-_Q22-Pad1_ 4.7K
R34 Net-_Q11-Pad3_ Net-_Q23-Pad1_ 4.7K
R35 Net-_Q12-Pad3_ Net-_Q24-Pad1_ 4.7K
R36 Net-_Q13-Pad3_ Net-_Q25-Pad1_ 4.7K
R37 Net-_Q14-Pad3_ Net-_Q26-Pad1_ 4.7K
SEG2 Net-_R14-Pad1_ Net-_R13-Pad1_ Net-_Q2-Pad3_ Net-_R12-Pad1_ Net-_R17-Pad1_ Net-_R11-Pad1_ Net-_R9-Pad1_ Net-_Q2-Pad3_ Net-_R15-Pad1_ Net-_R16-Pad1_ 0.56'' BLUE CA
SW1 chasis chasis NC_04 /Interlock/SW1_1 /Interlock/SW1_2 /Interlock/SW1_3 /Interlock/SW1_4 /Interlock/SW1_5 /Interlock/SW1_6 chasis SRBV170501
U1 NC_05 /Interlock/SW1_3 /Interlock/SW1_2 /Interlock/SW1_1 /Interlock/SW1_4 /Interlock/SW1_5 /Interlock/SW1_6 NC_06 +3V3 chasis chasis NC_07 +3V3 NC_08 /Interlock/SW2_1 /Interlock/SW2_2 /Interlock/SW2_3 /Interlock/SW2_4 /Interlock/SW2_5 /Interlock/SW2_6 NC_09 /Interlock/TMS /Interlock/TDI /Interlock/TCK /Interlock/TDO NC_10 /Interlock/CPLDRST NC_11 NC_12 NC_13 +3V3 chasis /Interlock/LOAD /Interlock/REMOTE /Interlock/SEL2_6 /Interlock/SEL1_6 /Interlock/SEL2_5 /Interlock/SEL1_5 /Interlock/SEL2_4 /Interlock/SEL1_4 /Interlock/SEL2_3 /Interlock/SEL1_3 /Interlock/SEL2_2 /Interlock/SEL1_2 +3V3 chasis /Interlock/SEL2_1 /Interlock/SEL1_1 NC_14 /Interlock/SEG1 /Interlock/SEG1_D /Interlock/SEG1_E /Interlock/SEG1_C /Interlock/SEG1_DP /Interlock/SEG1_B /Interlock/SEG1_A /Interlock/SEG1_F /Interlock/SEG1_G +3V3 chasis NC_15 NC_16 +3V3 NC_17 chasis /Interlock/SEG2_E /Interlock/SEG2_G /Interlock/SEG2_D /Interlock/SEG2_F /Interlock/SEG2_C /Interlock/SEG2_A /Interlock/SEG2_DP /Interlock/SEG2_B Net-_R18-Pad2_ NC_18 BCD1_0 BCD1_1 BCD1_2 chasis +3V3 BCD2_0 BCD2_1 BCD2_2 BCDM1_0 BCDM1_1 BCDM1_2 BCDM2_0 BCDM2_1 BCDM2_2 NC_19 NC_20 NC_21 chasis +3V3 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 EPM240T100
C43 /Interlock/CPLDRST chasis 104
R19 +3V3 /Interlock/CPLDRST 1K
J9 /Interlock/CPLDRST RST
U2 /Interlock/SEL1_1 Net-_R21-Pad1_ /Interlock/SEL2_1 Net-_R22-Pad1_ /Interlock/SEL1_2 Net-_R23-Pad1_ chasis Net-_R24-Pad1_ /Interlock/SEL2_2 Net-_R38-Pad1_ /Interlock/SEL1_3 Net-_R39-Pad1_ /Interlock/SEL2_3 +3V3 74HC04
U9 /Interlock/SEL1_4 Net-_R40-Pad1_ /Interlock/SEL2_4 Net-_R41-Pad1_ /Interlock/SEL1_5 Net-_R42-Pad1_ chasis Net-_R43-Pad1_ /Interlock/SEL2_5 Net-_R60-Pad1_ /Interlock/SEL1_6 Net-_R61-Pad1_ /Interlock/SEL2_6 +3V3 74HC04
R21 Net-_R21-Pad1_ Net-_Q3-Pad1_ 47K
R22 Net-_R22-Pad1_ Net-_Q4-Pad1_ 47K
R23 Net-_R23-Pad1_ Net-_Q5-Pad1_ 47K
R24 Net-_R24-Pad1_ Net-_Q6-Pad1_ 47K
R38 Net-_R38-Pad1_ Net-_Q7-Pad1_ 47K
R39 Net-_R39-Pad1_ Net-_Q8-Pad1_ 47K
R40 Net-_R40-Pad1_ Net-_Q9-Pad1_ 47K
R41 Net-_R41-Pad1_ Net-_Q10-Pad1_ 47K
R42 Net-_R42-Pad1_ Net-_Q11-Pad1_ 47K
R43 Net-_R43-Pad1_ Net-_Q12-Pad1_ 47K
R60 Net-_R60-Pad1_ Net-_Q13-Pad1_ 47K
R61 Net-_R61-Pad1_ Net-_Q14-Pad1_ 47K
R18 Net-_Q2-Pad1_ Net-_R18-Pad2_ 1K
J6 +3V3 /Remote/SWDIO /Remote/SWCLK chasis SWD
R46 Net-_J5-Pad9_ +3V3 330
C32 /Remote/RST chasis 104
R50 chasis Net-_R50-Pad2_ 10K
U6 /Remote/RXD /Remote/485RW /Remote/485RW /Remote/TXD chasis /Remote/A /Remote/B +3V3 MAX485E
C34 /Remote/X+ chasis 10pF
C35 /Remote/X- chasis 10pF
R51 chasis Net-_R51-Pad2_ 12K
R47 Net-_J5-Pad12_ +3V3 330
C36 chasis +3V3 104
R53 chasis /Remote/B 1K
R54 /Remote/A +3V3 1K
J7 /Remote/A chasis /Remote/B 485
C33 Net-_C33-Pad1_ chasis 104
U3 chasis +1V8 +3V3 AZ1117-1.8
C9 +3V3 chasis 104
C10 +1V8 chasis 22uF
Y1 /Remote/X+ chasis /Remote/X- chasis 30MHz
U4 Net-_R51-Pad2_ +3V3 chasis /Remote/RXP /Remote/RXN +1V8 /Remote/TXP /Remote/TXN chasis /Remote/X+ /Remote/X- +3V3 chasis +3V3 chasis +1V8 chasis +3V3 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 +1V8 +3V3 NC_34 NC_35 NC_36 NC_37 Net-_C33-Pad1_ chasis +3V3 chasis +3V3 +1V8 chasis +3V3 chasis Net-_R52-Pad1_ Net-_J5-Pad10_ +1V8 NC_38 chasis /Remote/SPI_CS /Remote/SPI_SCK /Remote/SPI_MOSI /Remote/SPI_MISO +3V3 +1V8 CH395Q
C13 chasis +3V3 104
C26 +1V8 chasis 104
R44 /Remote/RXN +3V3 49.9
R45 /Remote/RXP +3V3 49.9
R48 /Remote/TXN +3V3 49.9
R49 /Remote/TXP +3V3 49.9
C12 +3V3 chasis 104
C11 +3V3 chasis 2.2uF
C28 +1V8 chasis 104
C29 +1V8 chasis 104
C30 +1V8 chasis 104
C14 +3V3 chasis 104
C15 +3V3 chasis 104
C16 +3V3 chasis 104
C17 +3V3 chasis 104
C18 +3V3 chasis 104
C19 +3V3 chasis 104
C20 +3V3 chasis 104
C21 +3V3 chasis 104
C31 +1V8 chasis 104
U5 +3V3 NC_39 NC_40 NC_41 NC_42 NC_43 /Remote/RST chasis +3V3 NC_44 Net-_R52-Pad2_ /Remote/TXD /Remote/RXD /Remote/SPI_CS /Remote/SPI_SCK /Remote/SPI_MISO /Remote/SPI_MOSI NC_45 NC_46 NC_47 NC_48 /Remote/485RW chasis +3V3 BCDM2_2 BCDM2_1 BCDM2_0 BCDM1_2 BCDM1_1 BCDM1_0 BCD2_2 BCD2_1 BCD2_0 /Remote/SWDIO NC_49 NC_50 /Remote/SWCLK BCD1_2 BCD1_1 BCD1_0 NC_51 NC_52 NC_53 Net-_R50-Pad2_ NC_54 NC_55 chasis +3V3 STM32F030C8Tx
C22 +3V3 chasis 104
C23 +3V3 chasis 104
C24 +3V3 chasis 104
C25 +3V3 chasis 104
R52 Net-_R52-Pad1_ Net-_R52-Pad2_ 100
J2 /Remote/RST Conn_01x01
J5 /Remote/TXP /Remote/TXN /Remote/RXP +3V3 +3V3 /Remote/RXN chasis Net-_J5-Pad9_ Net-_J5-Pad10_ Net-_J5-Pad10_ Net-_J5-Pad12_ HR913550A
U7 Net-_C38-Pad2_ Net-_R59*1-Pad1_ chasis chasis +12V Net-_C37-Pad1_ Net-_C37-Pad2_ Net-_R55-Pad2_ SY8303
C37 Net-_C37-Pad1_ Net-_C37-Pad2_ 10nF
L1 Net-_C37-Pad1_ Net-_C38-Pad1_ 22uH 1A
C41 Net-_C38-Pad1_ chasis 10uF
R56 Net-_C38-Pad1_ Net-_C38-Pad2_ 100K
R58 Net-_C38-Pad2_ chasis 15K
R59 Net-_R59*1-Pad1_ Net-_R59-Pad2_ 51K
F1 +12V Net-_F1-Pad2_ 1A
J8 Net-_F1-Pad2_ chasis 12VDC
C38 Net-_C38-Pad1_ Net-_C38-Pad2_ 47pF
D2 +12V chasis 16V
C40 +12V chasis 2.2uF 50V
R55 +12V Net-_R55-Pad2_ 100K
C39 +12V chasis 104
D4 chasis Net-_D4-Pad2_ Red
R57 +3V3 Net-_D4-Pad2_ 300
RV1 Net-_R59-Pad2_ Net-_R59-Pad2_ chasis 100K
R59*1 Net-_R59*1-Pad1_ chasis 100K
SC1 chasis Conn_01x01
SC2 chasis Conn_01x01
SC3 chasis Conn_01x01
SC4 chasis Conn_01x01
U8 chasis +3V3 Net-_R20-Pad1_ AZ1117-3.3
C42 +3V3 chasis 22uF
D3 chasis +12V SS34
R20 Net-_R20-Pad1_ Net-_C38-Pad1_ 0
.end
