.title KiCad schematic
R13 VCell_12 S3 0
R14 VCell_0 S1 0
P12 VCell_8 VCell_7 CONN_2
P11 VCC_24V_DC BMU_ENABLE CONN_2
P8 RS485+ RS485- GND_LV NC_01 CONN_4
P10 HVIL_IN HVIL_OUT CONN_2
P4 VCell_12 VCell_0 CONN_2
P9 VCC_24V_DC GND_LV CONN_2
P7 VCC_Con+_Protect Precharge_CMD CONN_2
P6 VCC_Con+_Protect MAIN-_CMD AUX_MAIN- GND_CON CONN_4
P5 VCC_Con+_Protect MAIN+_CMD AUX_MAIN+ GND_CON CONN_4
J1 N.C._2_CAN CAN_H_ISO N.C._2_CAN N.C._2_CAN GND_ISO N.C._2_CAN CAN_L_ISO N.C._2_CAN N.C._2_CAN DB9
J3 CAN_H_ISO GND_ISO CAN_L_ISO N.C._2 NC_02 NC_03 HVIL_OUT NC_04 RS485+ NC_05 NC_06 BMU_ENABLE VCC_24V_DC NC_07 NC_08 NC_09 GND_LV NC_10 NC_11 CAN_L_ISO GND_ISO CAN_H_ISO N.C._2 GND_LV HVIL_IN GND_LV RS485- GND_LV NC_12 VCC_24V_DC GND_LV GND_LV N.C._2 NC_13 NC_14 GND_LV GND_LV DB37
J7 NC_15 NC_16 GND_CON MAIN+_CMD MAIN-_CMD NC_17 NC_18 Precharge_CMD GND_CON VCC_Con+_Protect GND_CON NC_19 GND_CON NC_20 GND_CON NC_21 NC_22 GND_CON NC_23 GND_CON NC_24 NC_25 AUX_MAIN+ AUX_MAIN- NC_26 NC_27 NC_28 NC_29 GND_CON NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 DB37
P1 NTC_1 NTC_1 VBAT- VBAT- NTC_2 NTC_2 VBAT- VBAT- NTC_3 NTC_3 VBAT- VBAT- CONN_6X2
R7 VCell_7 S2 R
R8 VCell_8 VCell_7 R
R9 VCell_9 VCell_8 R
R10 VCell_10 VCell_9 R
R11 VCell_11 VCell_10 R
R12 VCell_12 VCell_11 R
R6 VCell_5 S2 R
R1 VCell_0 VCell_1 R
R2 VCell_1 VCell_2 R
R3 VCell_2 VCell_3 R
R5 VCell_4 VCell_5 R
R4 VCell_3 VCell_4 R
P2 VCell_1 NTC_1 S1 VCell_10 VCell_0 VCell_11 NTC_2 VCell_12 NTC_3 S3 DIL10
P3 S2 NC_38 VCell_5 S2 VCell_4 VCell_7 VCell_3 VCell_8 VCell_2 VCell_9 N.C._1 N.C._1 N.C._1 N.C._1 N.C._1 N.C._1 DIL16
.end
