.title KiCad schematic
D1 Net-_C1-Pad1_ /RXIN PHOTODIODE
C1 Net-_C1-Pad1_ GND C
D2 Net-_C1-Pad1_ /RXIN PHOTODIODE
R6 Net-_C2-Pad1_ Net-_C2-Pad2_ 100k
R2 Net-_C1-Pad1_ VCC 0
C3 Net-_C3-Pad1_ GND 100nF
C6 VCC GND 100nF
C11 VCC GND 100nF
C12 VCC GND 100nF
R10 GND /P2_5 10k
C8 VCC GND 10uF
C13 Net-_C13-Pad1_ GND 100nF
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 130pF
R34 GND Net-_R32-Pad2_ R
R35 Net-_R33-Pad2_ GND R
L7 Net-_C15-Pad1_ Net-_C14-Pad1_ 2.2uH
L9 Net-_C16-Pad1_ Net-_C15-Pad1_ 1uH
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 82pF
C16 Net-_C16-Pad1_ Net-_C16-Pad2_ 24pF
C18 GND Net-_C18-Pad2_ 100nF
C17 GND VCC 100nF
C19 GND VCC 100nF
C20 GND VCC 100nF
R38 NC_01 NC_02 0
L5 Net-_C14-Pad1_ NC_03 2.2uH
L6 Net-_C14-Pad2_ NC_04 2.2uH
L8 Net-_C15-Pad2_ Net-_C14-Pad2_ 2.2uH
L10 Net-_C16-Pad2_ Net-_C15-Pad2_ 1uH
R3 Net-_C1-Pad1_ NC_05 0
R9 NC_06 /P2_5 0
R23 Net-_R23-Pad1_ VCC 0
R19 /P2_5 NC_07 0
R20 NC_08 GND 0
R32 Net-_C16-Pad1_ Net-_R32-Pad2_ 0
R33 Net-_C16-Pad2_ Net-_R33-Pad2_ 0
R31 Net-_C13-Pad1_ Net-_C18-Pad2_ 0
R36 NC_09 VCC 10k
R21 Net-_R21-Pad1_ /ADC0_0 0
R26 Net-_R23-Pad1_ NC_10 0
R29 NC_11 NC_12 0
R39 NC_13 NC_14 0
R40 NC_15 NC_16 0
R41 NC_17 NC_18 0
R42 NC_19 NC_20 0
R43 NC_21 NC_22 0
R44 NC_23 NC_24 0
R45 NC_25 NC_26 0
R30 Net-_Q1-Pad2_ GND 75
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ NC_27 Q_NPN_BEC
R24 Net-_C25-Pad1_ NC_28 1k
R4 Net-_C1-Pad1_ GND 0
R1 Net-_C3-Pad1_ Net-_C1-Pad1_ 0
R14 Net-_C7-Pad1_ GND R
R13 VCC Net-_C7-Pad1_ R
C7 Net-_C7-Pad1_ GND 100nF
R11 Net-_C3-Pad1_ Net-_C4-Pad1_ R
C4 Net-_C4-Pad1_ Net-_C3-Pad1_ C
R12 Net-_C3-Pad1_ Net-_C7-Pad1_ R
R5 /RXIN Net-_C5-Pad1_ R
C5 Net-_C5-Pad1_ GND 100nF
R17 GND Net-_R15-Pad2_ R
R18 Net-_R16-Pad2_ GND R
L1 Net-_C9-Pad1_ Net-_C2-Pad1_ 2.2uH
L3 Net-_C10-Pad1_ Net-_C9-Pad1_ 1.5uH
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 100pF
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 15pF
L2 Net-_C9-Pad2_ Net-_C4-Pad1_ 2.2uH
R15 Net-_C10-Pad1_ Net-_R15-Pad2_ 0
R16 Net-_C10-Pad2_ Net-_R16-Pad2_ 0
L4 Net-_C10-Pad2_ Net-_C9-Pad2_ 1.5uH
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 15pF
R8 GND Net-_C3-Pad1_ 1.74k
R7 Net-_C3-Pad1_ VCC 3.24k
R37 /ADCCLK GND R
R22 Net-_R21-Pad1_ NC_29 0
R46 /ADCCLK NC_30 39
R71 Net-_C26-Pad1_ Net-_C26-Pad2_ 953
C27 VCC GND 100nF
C21 VCC GND 100nF
C22 VCC GND 100nF
C23 VCC GND 100nF
C26 Net-_C26-Pad1_ Net-_C26-Pad2_ 15pF
R70 Net-_C26-Pad1_ GND 1.80k
C25 Net-_C25-Pad1_ GND 100nF
R57 GND NC_31 20k
R54 /DACCLK NC_32 39
R28 NC_33 NC_34 39
R47 NC_35 NC_36 39
R48 NC_37 NC_38 39
R49 NC_39 NC_40 39
R50 NC_41 NC_42 39
R51 NC_43 NC_44 39
R52 NC_45 NC_46 39
R53 NC_47 NC_48 39
R56 /DACCLK GND R
R60 VCC /P5_3 10k
R61 /P5_3 GND 10k
R58 VCC /P5_2 10k
R59 /P5_2 GND 10k
R63 /P5_5 GND 10k
R62 VCC /P5_5 10k
R55 VCC NC_49 10k
R69 Net-_C26-Pad1_ NC_50 249
R67 Net-_C24-Pad2_ Net-_C25-Pad1_ 0
R66 NC_51 GND 249
C24 GND Net-_C24-Pad2_ 100nF
R73 Net-_Q1-Pad1_ Net-_C29-Pad1_ 1k
R72 Net-_C26-Pad2_ NC_52 0
R74 Net-_C29-Pad2_ Net-_Q1-Pad2_ 0
R25 Net-_C25-Pad1_ NC_53 1k
R27 Net-_C25-Pad1_ GND 10k
R75 NC_54 VCC 12k
C28 /RXIN Net-_C2-Pad2_ 8nF
R76 /RXIN GND 1M
R77 Net-_R77-Pad1_ NC_55 0
R78 NC_56 Net-_R77-Pad1_ 0
C29 Net-_C29-Pad1_ Net-_C29-Pad2_ 470pF
R64 Net-_Q1-Pad2_ /ADC0_0 0
.end
