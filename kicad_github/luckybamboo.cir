.title KiCad schematic
J2 GND NC_01 NC_02 NC_03 NC_04 NC_05 /P4_4 NC_06 /P4_3 NC_07 NC_08 NC_09 NC_10 NC_11 /P2_6 /P7_7 NC_12 /P2_5 /P2_4 NC_13 NC_14 NC_15 /P7_2 /P3_1 /P7_1 NC_16 /P7_0 NC_17 /P6_8 NC_18 /P6_7 NC_19 /P2_2 /P6_6 /P2_1 /P6_3 NC_20 NC_21 NC_22 NC_23 NEIGHBOR2
J1 GND VCC /P4_9 NC_24 /P4_10 NC_25 /P1_0 NC_26 NC_27 NC_28 NC_29 NC_30 /P1_5 /P5_2 NC_31 /P1_6 NC_32 /P1_8 NC_33 NC_34 /P1_12 NC_35 NC_36 NC_37 /P1_14 /P1_13 NC_38 /P1_15 NC_39 /P1_16 NC_40 /P1_17 /P9_5 /P9_6 /P2_0 NC_41 /P1_20 /P1_19 /P1_4 /P1_3 NEIGHBOR1
J7 GND NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 GND NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 GND VCC BONUS_ROW
MH3 GND MOUNTING_HOLE
MH4 GND MOUNTING_HOLE
MH1 GND MOUNTING_HOLE
MH2 GND MOUNTING_HOLE
U1 GND Net-_C3-Pad2_ Net-_R1-Pad2_ Net-_C1-Pad2_ /RFIN1_P /RFIN1_N /RFOUT1_P /RFOUT1_N Net-_C6-Pad1_ Net-_C10-Pad1_ Net-_C10-Pad1_ Net-_C11-Pad1_ Net-_C21-Pad1_ Net-_C28-Pad1_ Net-_C24-Pad1_ Net-_C24-Pad1_ /DR1 /DT1 /TRFS1 /P1_12 /IRQ1 /P1_3 /P1_19 /P1_4 /~CS~1 /TXEN1 NC_58 Net-_C23-Pad2_ /XOSC32KP1 /XOSC32KN1 VCC /PAVSUP1 /PABIAOP1 ADF7242
C5 GND Net-_C3-Pad2_ 27pF
C3 GND Net-_C3-Pad2_ 220nF
R1 GND Net-_R1-Pad2_ 27k
C1 GND Net-_C1-Pad2_ 100pF
C6 Net-_C6-Pad1_ GND 100pF
C10 Net-_C10-Pad1_ GND 220nF
C16 Net-_C10-Pad1_ GND 27pF
C11 Net-_C11-Pad1_ GND 220nF
C17 Net-_C11-Pad1_ GND 27pF
C21 Net-_C21-Pad1_ GND 18pF
C28 Net-_C28-Pad1_ GND 18pF
X1 Net-_C21-Pad1_ GND Net-_C28-Pad1_ GND XTAL4PIN
C24 Net-_C24-Pad1_ GND 220nF
C27 Net-_C24-Pad1_ GND 27pF
C23 GND Net-_C23-Pad2_ 1nF
J17 Net-_C63-Pad2_ GND Conn_Coaxial
J18 Net-_C83-Pad2_ GND Conn_Coaxial
U3 GND Net-_C4-Pad2_ Net-_R2-Pad2_ Net-_C2-Pad2_ /RFIN3_P /RFIN3_N /RFOUT3_P /RFOUT3_N Net-_C8-Pad1_ Net-_C13-Pad1_ Net-_C13-Pad1_ Net-_C14-Pad1_ Net-_C22-Pad1_ Net-_C30-Pad1_ Net-_C26-Pad1_ Net-_C26-Pad1_ /DR3 /DT3 /TRFS3 /P1_14 /IRQ3 /P1_3 /P1_19 /P1_4 /~CS~3 /TXEN3 NC_59 Net-_C25-Pad2_ /XOSC32KP3 /XOSC32KN3 VCC /PAVSUP3 /PABIAOP3 ADF7242
C7 GND Net-_C4-Pad2_ 27pF
C4 GND Net-_C4-Pad2_ 220nF
R2 GND Net-_R2-Pad2_ 27k
C2 GND Net-_C2-Pad2_ 100pF
C8 Net-_C8-Pad1_ GND 100pF
C13 Net-_C13-Pad1_ GND 220nF
C19 Net-_C13-Pad1_ GND 27pF
C14 Net-_C14-Pad1_ GND 220nF
C20 Net-_C14-Pad1_ GND 27pF
C22 Net-_C22-Pad1_ GND 18pF
C30 Net-_C30-Pad1_ GND 18pF
X2 Net-_C22-Pad1_ GND Net-_C30-Pad1_ GND XTAL4PIN
C26 Net-_C26-Pad1_ GND 220nF
C29 Net-_C26-Pad1_ GND 27pF
C25 GND Net-_C25-Pad2_ 1nF
U2 GND Net-_C33-Pad2_ Net-_R5-Pad2_ Net-_C31-Pad2_ /RFIN2_P /RFIN2_N /RFOUT2_P /RFOUT2_N Net-_C36-Pad1_ Net-_C40-Pad1_ Net-_C40-Pad1_ Net-_C41-Pad1_ Net-_C51-Pad1_ Net-_C58-Pad1_ Net-_C54-Pad1_ Net-_C54-Pad1_ /DR2 /DT2 /TRFS2 /P1_13 /IRQ2 /P1_3 /P1_19 /P1_4 /~CS~2 /TXEN2 NC_60 Net-_C53-Pad2_ /XOSC32KP2 /XOSC32KN2 VCC /PAVSUP2 /PABIAOP2 ADF7242
C35 GND Net-_C33-Pad2_ 27pF
C33 GND Net-_C33-Pad2_ 220nF
R5 GND Net-_R5-Pad2_ 27k
C31 GND Net-_C31-Pad2_ 100pF
C36 Net-_C36-Pad1_ GND 100pF
C40 Net-_C40-Pad1_ GND 220nF
C46 Net-_C40-Pad1_ GND 27pF
C41 Net-_C41-Pad1_ GND 220nF
C47 Net-_C41-Pad1_ GND 27pF
C51 Net-_C51-Pad1_ GND 18pF
C58 Net-_C58-Pad1_ GND 18pF
X3 Net-_C51-Pad1_ GND Net-_C58-Pad1_ GND XTAL4PIN
C54 Net-_C54-Pad1_ GND 220nF
C57 Net-_C54-Pad1_ GND 27pF
C53 GND Net-_C53-Pad2_ 1nF
U4 GND Net-_C34-Pad2_ Net-_R6-Pad2_ Net-_C32-Pad2_ /RFIN4_P /RFIN4_N /RFOUT4_P /RFOUT4_N Net-_C38-Pad1_ Net-_C43-Pad1_ Net-_C43-Pad1_ Net-_C44-Pad1_ Net-_C52-Pad1_ Net-_C60-Pad1_ Net-_C56-Pad1_ Net-_C56-Pad1_ /DR4 /DT4 /TRFS4 /P1_17 /IRQ4 /P1_3 /P1_19 /P1_4 /~CS~4 /TXEN4 NC_61 Net-_C55-Pad2_ /XOSC32KP4 /XOSC32KN4 VCC /PAVSUP4 /PABIAOP4 ADF7242
C37 GND Net-_C34-Pad2_ 27pF
C34 GND Net-_C34-Pad2_ 220nF
R6 GND Net-_R6-Pad2_ 27k
C32 GND Net-_C32-Pad2_ 100pF
C38 Net-_C38-Pad1_ GND 100pF
C43 Net-_C43-Pad1_ GND 220nF
C49 Net-_C43-Pad1_ GND 27pF
C44 Net-_C44-Pad1_ GND 220nF
C50 Net-_C44-Pad1_ GND 27pF
C52 Net-_C52-Pad1_ GND 18pF
C60 Net-_C60-Pad1_ GND 18pF
X4 Net-_C52-Pad1_ GND Net-_C60-Pad1_ GND XTAL4PIN
C56 Net-_C56-Pad1_ GND 220nF
C59 Net-_C56-Pad1_ GND 27pF
C55 GND Net-_C55-Pad2_ 1nF
R3 VCC /~CS~1 10k
R7 VCC /~CS~2 10k
R4 VCC /~CS~3 10k
R8 VCC /~CS~4 10k
C15 GND VCC 27pF
C39 GND VCC 220nF
C45 GND VCC 27pF
C42 GND VCC 220nF
C48 GND VCC 27pF
C12 GND VCC 220nF
C18 GND VCC 27pF
J19 /~CS~1 /P4_3 TEST_2P
J20 /~CS~1 /P4_4 TEST_2P
J21 /~CS~2 /P5_2 TEST_2P
J22 /~CS~2 /P1_6 TEST_2P
J23 /~CS~3 /P6_7 TEST_2P
J24 /~CS~3 /P3_1 TEST_2P
J25 /~CS~4 /P9_6 TEST_2P
J26 /~CS~4 /P9_5 TEST_2P
J9 /DR1 /P6_3 TEST_2P
J10 /DR1 /P2_5 TEST_2P
J11 /DR2 /P1_0 TEST_2P
J12 /DR2 /P1_5 TEST_2P
J13 /DR3 /P2_2 TEST_2P
J14 /DR3 /P6_8 TEST_2P
J15 /DR4 /P1_16 TEST_2P
J16 /DR4 /P1_20 TEST_2P
U5 GND Net-_C62-Pad2_ /P7_2 NC_62 /P2_4 Net-_C66-Pad1_ Net-_C82-Pad2_ /P7_1 Net-_C83-Pad1_ /P7_0 Net-_C67-Pad1_ SKY13322
U9 /RFOUT1 GND Net-_C69-Pad1_ Net-_C65-Pad1_ GND GND ADF7242_balun
C65 Net-_C65-Pad1_ /RFOUT1_P 10nF
C69 Net-_C69-Pad1_ /RFOUT1_N 10nF
U11 /RFOUT2 GND Net-_C73-Pad1_ Net-_C71-Pad1_ GND GND ADF7242_balun
C71 Net-_C71-Pad1_ /RFOUT2_P 10nF
C73 Net-_C73-Pad1_ /RFOUT2_N 10nF
U15 /RFOUT3 GND Net-_C77-Pad1_ Net-_C75-Pad1_ GND GND ADF7242_balun
C75 Net-_C75-Pad1_ /RFOUT3_P 10nF
C77 Net-_C77-Pad1_ /RFOUT3_N 10nF
U17 /RFOUT4 GND Net-_C81-Pad1_ Net-_C79-Pad1_ GND GND ADF7242_balun
C79 Net-_C79-Pad1_ /RFOUT4_P 10nF
C81 Net-_C81-Pad1_ /RFOUT4_N 10nF
U8 /RFIN1 GND Net-_C68-Pad1_ Net-_C64-Pad1_ GND GND ADF7242_balun
C64 Net-_C64-Pad1_ /RFIN1_P 10nF
C68 Net-_C68-Pad1_ /RFIN1_N 10nF
U10 /RFIN2 GND Net-_C72-Pad1_ Net-_C70-Pad1_ GND GND ADF7242_balun
C70 Net-_C70-Pad1_ /RFIN2_P 10nF
C72 Net-_C72-Pad1_ /RFIN2_N 10nF
U14 /RFIN3 GND Net-_C76-Pad1_ Net-_C74-Pad1_ GND GND ADF7242_balun
C74 Net-_C74-Pad1_ /RFIN3_P 10nF
C76 Net-_C76-Pad1_ /RFIN3_N 10nF
U16 /RFIN4 GND Net-_C80-Pad1_ Net-_C78-Pad1_ GND GND ADF7242_balun
C78 Net-_C78-Pad1_ /RFIN4_P 10nF
C80 Net-_C80-Pad1_ /RFIN4_N 10nF
L1 /RFIN Net-_C63-Pad1_ 3.8nH
C63 Net-_C63-Pad1_ Net-_C63-Pad2_ 1nF
J3 /PABIAOP1 /PAVSUP1 /XOSC32KN1 /XOSC32KP1 /TXEN1 /IRQ1 /TRFS1 /DT1 Conn_01x08
C9 GND VCC 220nF
J5 /PABIAOP2 /PAVSUP2 /XOSC32KN2 /XOSC32KP2 /TXEN2 /IRQ2 /TRFS2 /DT2 Conn_01x08
J4 /PABIAOP3 /PAVSUP3 /XOSC32KN3 /XOSC32KP3 /TXEN3 /IRQ3 /TRFS3 /DT3 Conn_01x08
J27 /P7_7 /TRFS1 TEST_2P
J8 /P2_6 /IRQ1 TEST_2P
J30 /P1_8 /IRQ2 TEST_2P
J31 /P4_9 /TRFS2 TEST_2P
J28 /P6_6 /IRQ3 TEST_2P
J29 /P2_1 /TRFS3 TEST_2P
J32 /P2_0 /IRQ4 TEST_2P
J33 /P1_15 /TRFS4 TEST_2P
U7 /RFIN3 GND /RFIN1 GND Net-_R11-Pad2_ GND HHM2293A1
U6 /RFIN2 GND /RFIN4 GND Net-_R11-Pad1_ GND HHM2293A1
R11 Net-_R11-Pad1_ Net-_R11-Pad2_ 100
R9 /RFIN4 /RFIN2 100
R10 /RFIN1 /RFIN3 100
C61 GND VCC 1nF
U13 GND VCC Net-_U12-Pad5_ GND /RFIN /P4_10 BGA7H1N6
J6 /PABIAOP4 /PAVSUP4 /XOSC32KN4 /XOSC32KP4 /TXEN4 /IRQ4 /TRFS4 /DT4 Conn_01x08
U12 Net-_R11-Pad2_ GND Net-_R11-Pad1_ GND Net-_U12-Pad5_ GND HHM2293A1
C66 Net-_C66-Pad1_ /RFOUT1 47pF
C62 /RFOUT2 Net-_C62-Pad2_ 47pF
C67 Net-_C67-Pad1_ /RFOUT4 47pF
C82 /RFOUT3 Net-_C82-Pad2_ 47pF
C83 Net-_C83-Pad1_ Net-_C83-Pad2_ 47pF
.end
