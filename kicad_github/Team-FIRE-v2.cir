.title KiCad schematic
C15 +5V GND 0.1uF
J2 NC_01 NC_02 NC_03 NC_04 GND GND NC_05 NC_06 NC_07 NC_08 GND GND NC_09 NC_10 RX TX CTS DCD DSR RI RTS DTR NC_11 IR_SIM_CLOCK IR_SIM_EN IR_SIM_RESET IR_SIM_IO RF_EN 3.3V_SENSE MODE_SW TX_ACTIVE PWR_EN BOOST_EN GND GND +5V +30V +5V +30V +5V 53885-0408
C6 SIM_VCC GND 1uF
U2 NC_12 NC_13 +5V NC_14 +5V NC_15 SIM_VCC SIM_IO SIM_RESET GND SIM_CLOCK NC_16 IR_SIM_CLOCK IR_SIM_RESET IR_SIM_IO NC_17 GND NCN4555MN
C5 +5V GND 0.1u
JP1 MODE_SW RF_EN SolderJumper_2_Open
R8 RF_EN GND 100k
C9 +8V GND 10uF
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 100pF
C1 Net-_C1-Pad1_ GND 33nF
R1 Net-_C3-Pad1_ Net-_C4-Pad1_ 12.1k
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 1.5nF
C4 Net-_C4-Pad1_ Net-_C3-Pad2_ 27nF
R3 Net-_C2-Pad1_ +8V 301k
C8 GND Net-_C8-Pad2_ 1uF
R4 Net-_C3-Pad1_ +30V 47.5k
R5 Net-_Q1-Pad4_ Net-_R5-Pad2_ 19.1
R6 Net-_Q1-Pad1_ Net-_C7-Pad1_ 1k
R7 Net-_Q1-Pad1_ GND 15m
C7 Net-_C7-Pad1_ GND 150pF
C10 +8V GND 470nF
R2 Net-_C3-Pad1_ GND 1.13k
C13 +30V GND 2.2uF
U1 Net-_C2-Pad2_ Net-_C1-Pad1_ NC_18 Net-_C3-Pad2_ Net-_C3-Pad1_ GND Net-_C7-Pad1_ Net-_R5-Pad2_ Net-_C8-Pad2_ +8V TPS40210DGQR
C16 +30V GND 0.1uF
C12 MODE_SW GND 1uF
C14 MODE_SW GND 10uF
C11 +30V GND +30V +30V GND GND 39uF
CR1 +30V Net-_CR1-Pad2_ B260-13-F
L1 Net-_CR1-Pad2_ +8V 24uH
J1 SIM_CLOCK SIM_RESET SIM_VCC SIM_IO NC_19 GND GND GND 47388-2001
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad1_ Net-_Q1-Pad4_ Net-_CR1-Pad2_ Net-_CR1-Pad2_ Net-_CR1-Pad2_ Net-_CR1-Pad2_ Net-_CR1-Pad2_ CSD18543Q3AT
D4 TX_LED Net-_D4-Pad2_ Orange
D5 RX_LED Net-_D5-Pad2_ Yellow
R10 EN_IR_BUS GND 10k
U7 MODE_SW SYS-TX SYS-RX NC_20 TX_ACTIVE GND TES-GPS-FLAG NC_21 TES-RX TES-TX Net-_C19-Pad2_ EN_IR_BUS TXB0104RUT
JP2 3.3V_SENSE GND MODE_SW SolderJumper_3_Bridged12
C20 GND MODE_SW 0.1uF
C19 GND Net-_C19-Pad2_ 0.1uF
C18 MODE_SW GND 0.1uF
C17 GND Net-_C17-Pad2_ 0.1uF
J5 MODE_SW SWDIO GND SWCLK GND NC_22 NC_23 NC_24 NC_25 RST Conn_ARM_JTAG_SWD_10
R12 Net-_D4-Pad2_ MODE_SW 330
R14 Net-_D5-Pad2_ MODE_SW 330
J3 NC_26 USB_D- USB_D+ NC_27 GND GND GND GND GND UX60-MB-5ST
R9 EN_IR_BUS GND 10k
U4 DTR RI DCD RTS Net-_C17-Pad2_ EN_IR_BUS DSR CTS RX TX IO-TX IO-RX IO-CTS IO-DSR GND MODE_SW IO-RTS IO-DCD IO-RI IO-DTR TXB0108DQSR
J4 MODE_SW Net-_C19-Pad2_ +5V GND Conn_01x03
R18 MODE_SW SWCLK 1k
C29 RST GND 100nF
SW1 GND Net-_R17-Pad1_ RESET
R17 Net-_R17-Pad1_ RST 330
R15 MODE_SW RST 10k
U5 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 GND MODE_SW NC_37 NC_38 NC_39 8V_ISENSE NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 GND Net-_U5-Pad25_ FLASH_MOSI FLASH_SCK FLASH_CS FLASH_MISO Net-_U5-Pad25_ GND IO-DTR NC_47 NC_48 NC_49 NC_50 NC_51 GND MODE_SW NC_52 8V_EN NC_53 NC_54 EN_IR_BUS TX_ACTIVE IO-CTS NC_55 IO-DSR IO-RTS GND MODE_SW IO-DCD NC_56 IO-TX IO-RX NC_57 BOOST_EN PWR_EN NC_58 NC_59 NC_60 GND MODE_SW NC_61 NC_62 IO-RI NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 USB_D- USB_D+ GND MODE_SW SYS-TX SYS-RX NC_70 NC_71 NC_72 NC_73 NC_74 NC_75 NC_76 TX_LED RST VDDCORE GND VSW MODE_SW SWCLK SWDIO NC_77 NC_78 NC_79 NC_80 NC_81 RX_LED SAMD51
R16 MODE_SW FLASH_CS 10k
C21 MODE_SW GND 10uF
C22 MODE_SW GND 10uF
C23 MODE_SW GND 10uF
C24 MODE_SW GND 10uF
C25 MODE_SW GND 10uF
C26 MODE_SW GND 100nF
C27 VDDCORE GND 4.7uF
C28 VDDCORE GND 100nF
L2 VDDCORE VSW 10uH
U6 FLASH_CS FLASH_MISO FLASH_CS GND FLASH_MOSI FLASH_SCK FLASH_CS MODE_SW AT25DF041B-SSHN-T
IC2 GND Net-_IC2-Pad2_ NC_82 Net-_IC2-Pad4_ VBAT BTS500601TEAAUMA2
TP1 EN_IR_BUS TestPoint
J6 GND TES-RX TES-TX Conn_01x03
J10 Net-_J10-Pad1_ GND GND GND GND PCB.MMCX.F.ST.SMT.JACK.HT
J8 TES-GPS-FLAG VBAT Conn_01x02
R21 +5V Net-_R21-Pad2_ 523k
C34 Net-_C34-Pad1_ GND 430pF
C33 +5V GND 47uF
U8 VBAT VBAT GND +5V +5V Net-_R21-Pad2_ Net-_R19-Pad1_ Net-_C34-Pad1_ GND TPS82140
IC1 TES-EN +5V GND MODE_SW Net-_IC1-Pad5_ GND MCP1826T-3302E_DC
J9 GND GND Net-_J10-Pad1_ U.FL-R-SMT_10_
J7 GND TES-EN TES-GPS-FLAG Conn_01x03
R23 GND Net-_IC2-Pad4_ 1k
C35 MODE_SW GND 1uF
R22 8V_ISENSE Net-_IC2-Pad4_ 10k
R20 8V_EN Net-_IC2-Pad2_ 10k
C32 VBAT GND 10uF
R19 Net-_R19-Pad1_ +5V 100k
R24 Net-_R21-Pad2_ GND 100k
R25 MODE_SW Net-_IC1-Pad5_ 1k
TP3 TX_ACTIVE TestPoint
TP5 BOOST_EN TestPoint
TP7 IR_SIM_EN TestPoint
TP2 MODE_SW TestPoint
TP4 +5V TestPoint
TP6 PWR_EN TestPoint
TP8 RF_EN TestPoint
.end
