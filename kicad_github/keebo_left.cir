.title KiCad schematic
SW1 Net-_D1-Pad2_ /col1 SW_Push
D1 /row1 Net-_D1-Pad2_ 1N4148
J2 /col1 /col2 /col3 /col4 /col5 /col6 /col7 NC_01 Conn_01x08
J1 /row1 /row2 /row3 /row4 /row5 Conn_01x05
SW2 Net-_D2-Pad2_ /col2 SW_Push
D2 /row1 Net-_D2-Pad2_ 1N4148
SW3 Net-_D3-Pad2_ /col3 SW_Push
D3 /row1 Net-_D3-Pad2_ 1N4148
SW4 Net-_D4-Pad2_ /col4 SW_Push
D4 /row1 Net-_D4-Pad2_ 1N4148
SW5 Net-_D5-Pad2_ /col5 SW_Push
D5 /row1 Net-_D5-Pad2_ 1N4148
SW6 Net-_D6-Pad2_ /col6 SW_Push
D6 /row1 Net-_D6-Pad2_ 1N4148
SW7 Net-_D7-Pad2_ /col7 SW_Push
D7 /row1 Net-_D7-Pad2_ 1N4148
SW9 Net-_D9-Pad2_ /col1 SW_Push
D9 /row2 Net-_D9-Pad2_ 1N4148
SW10 Net-_D10-Pad2_ /col2 SW_Push
D10 /row2 Net-_D10-Pad2_ 1N4148
SW11 Net-_D11-Pad2_ /col3 SW_Push
D11 /row2 Net-_D11-Pad2_ 1N4148
SW12 Net-_D12-Pad2_ /col4 SW_Push
D12 /row2 Net-_D12-Pad2_ 1N4148
SW13 Net-_D13-Pad2_ /col5 SW_Push
D13 /row2 Net-_D13-Pad2_ 1N4148
SW17 Net-_D17-Pad2_ /col1 SW_Push
D17 /row3 Net-_D17-Pad2_ 1N4148
SW18 Net-_D18-Pad2_ /col2 SW_Push
D18 /row3 Net-_D18-Pad2_ 1N4148
SW19 Net-_D19-Pad2_ /col3 SW_Push
D19 /row3 Net-_D19-Pad2_ 1N4148
SW20 Net-_D20-Pad2_ /col4 SW_Push
D20 /row3 Net-_D20-Pad2_ 1N4148
SW21 Net-_D21-Pad2_ /col5 SW_Push
D21 /row3 Net-_D21-Pad2_ 1N4148
SW22 Net-_D22-Pad2_ /col6 SW_Push
D22 /row3 Net-_D22-Pad2_ 1N4148
SW33 Net-_D33-Pad2_ /col1 SW_Push
D33 /row5 Net-_D33-Pad2_ 1N4148
SW35 Net-_D35-Pad2_ /col3 SW_Push
D35 /row5 Net-_D35-Pad2_ 1N4148
SW36 Net-_D36-Pad2_ /col4 SW_Push
D36 /row5 Net-_D36-Pad2_ 1N4148
SW37 Net-_D37-Pad2_ /col5 SW_Push
D37 /row5 Net-_D37-Pad2_ 1N4148
SW25 Net-_D25-Pad2_ /col1 SW_Push
D25 /row4 Net-_D25-Pad2_ 1N4148
SW26 Net-_D26-Pad2_ /col2 SW_Push
D26 /row4 Net-_D26-Pad2_ 1N4148
SW27 Net-_D27-Pad2_ /col3 SW_Push
D27 /row4 Net-_D27-Pad2_ 1N4148
SW28 Net-_D28-Pad2_ /col4 SW_Push
D28 /row4 Net-_D28-Pad2_ 1N4148
SW29 Net-_D29-Pad2_ /col5 SW_Push
D29 /row4 Net-_D29-Pad2_ 1N4148
SW30 Net-_D30-Pad2_ /col6 SW_Push
D30 /row4 Net-_D30-Pad2_ 1N4148
D14 /row2 Net-_D14-Pad2_ 1N4148
SW14 Net-_D14-Pad2_ /col6 SW_Push
.end
