.title KiCad schematic
C7 +3V3 GND 0.1u
U3 +3V3 NC_01 NC_02 GND GND Net-_R14-Pad2_ /MDRIVE4 +3V3 ADUM3221BRZ
D3 GND Net-_D3-PadC_ MBR0520LT
C6 +3V3 GND 0.1u
C11 +3V3 GND 10u
C10 +3V3 GND 10u
PTC8 NC_03 Net-_D3-PadC_ 2.5A
T4 Net-_R12-Pad1_ Net-_D3-PadC_ GND Net-_D3-PadC_ NMOSSOT223
D2 GND Net-_D2-PadC_ MBR0520LT
PTC7 NC_04 Net-_D2-PadC_ 2.5A
T3 Net-_R11-Pad1_ Net-_D2-PadC_ GND Net-_D2-PadC_ NMOSSOT223
R12 Net-_R12-Pad1_ /MDRIVE3 10
R11 Net-_R11-Pad1_ /MDRIVE2 10
R13 Net-_R13-Pad1_ /MDRIVE4 10
PTC1 NC_05 Net-_D5-PadC_ 2.5A
T5 Net-_R13-Pad1_ Net-_D5-PadC_ GND Net-_D5-PadC_ NMOSSOT223
D5 GND Net-_D5-PadC_ MBR0520LT
D6 GND Net-_D6-PadC_ MBR0520LT
T6 Net-_R14-Pad1_ Net-_D6-PadC_ GND Net-_D6-PadC_ NMOSSOT223
PTC2 NC_06 Net-_D6-PadC_ 2.5A
R14 Net-_R14-Pad1_ Net-_R14-Pad2_ 10
R15 Net-_R15-Pad1_ /MDRIVE6 10
R16 Net-_R16-Pad1_ /MDRIVE7 10
R8 GND +3V3 10k
R4 GND +3V3 10k
PTC3 NC_07 Net-_D7-PadC_ 2.5A
PTC4 NC_08 Net-_D8-PadC_ 2.5A
C4 +3V3 GND 0.1u
C12 +3V3 GND 10u
U4 +3V3 NC_09 NC_10 GND GND /MDRIVE7 /MDRIVE6 +3V3 ADUM3221BRZ
C8 +3V3 GND 0.1u
T7 Net-_R15-Pad1_ Net-_D7-PadC_ GND Net-_D7-PadC_ NMOSSOT223
D7 GND Net-_D7-PadC_ MBR0520LT
T8 Net-_R16-Pad1_ Net-_D8-PadC_ GND Net-_D8-PadC_ NMOSSOT223
D8 GND Net-_D8-PadC_ MBR0520LT
R10 Net-_R10-Pad1_ /MDRIVE1 10
R9 Net-_R9-Pad1_ /MDRIVE0 10
T1 Net-_R9-Pad1_ Net-_D1-PadC_ GND Net-_D1-PadC_ NMOSSOT223
PTC5 NC_11 Net-_D1-PadC_ 2.5A
D1 GND Net-_D1-PadC_ MBR0520LT
T2 Net-_R10-Pad1_ Net-_D4-PadC_ GND Net-_D4-PadC_ NMOSSOT223
PTC6 NC_12 Net-_D4-PadC_ 2.5A
D4 GND Net-_D4-PadC_ MBR0520LT
C9 +3V3 GND 10u
C5 +3V3 GND 0.1u
U1 +3V3 NC_13 NC_14 GND GND /MDRIVE1 /MDRIVE0 +3V3 ADUM3221BRZ
R7 GND +3V3 10k
R3 GND +3V3 10k
C3 +3V3 GND 0.1u
R6 GND +3V3 10k
R2 GND +3V3 10k
C2 +3V3 GND 0.1u
R5 GND +3V3 10k
R1 GND +3V3 10k
C1 +3V3 GND 0.1u
U2 +3V3 NC_15 NC_16 GND GND /MDRIVE3 /MDRIVE2 +3V3 ADUM3221BRZ
.end
