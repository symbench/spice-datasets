.title KiCad schematic
P1 +3.3V GND /E5 /E6 /C0 /C1 /C2 /C3 /A0 /A1 /A2 /A3 NC_01 NC_02 /A6 /A7 NC_03 NC_04 /B0 /B1 NC_05 /E9 /E10 /E11 /E12 /E13 /E14 /B10 NC_06 /B11 CONN_02X15
P2 GND +5V /B8 /B9 /B6 NC_07 NC_08 /B5 /D6 NC_09 NC_10 /D5 NC_11 NC_12 /A10 NC_13 NC_14 /A9 /C8 /C9 /C6 NC_15 /D14 /D15 /D12 /D13 /D8 /D9 /B15 /B14 CONN_02X15
P12 GND +5V 5V_in
R5 +5V Net-_D1-Pad1_ 510
D1 Net-_D1-Pad1_ GND LED
R6 +3.3V Net-_D2-Pad1_ 330
D2 Net-_D2-Pad1_ GND LED
P10 GND NC_16 /CLK /DIO NC_17 NC_18 WRITING
U1 /B6 GND +3.3V /B5 GND /CAN_L /CAN_H Net-_R1-Pad1_ MAX3051
P3 GND +12V /CAN_H /CAN_L CAN
P4 GND +12V /CAN_H /CAN_L CAN
C1 +3.3V GND 0.1u
P7 GND +5V /A9 /A10 SERIAL2
C3 +5V GND 0.1u
P8 GND NC_19 /CLK /DIO WRITING_IN
C4 +12V GND 0.1u
SW2 GND /E10 SW0
R7 +5V /E10 10k
D3 Net-_D3-Pad1_ GND LED
D4 Net-_D4-Pad1_ GND LED
R3 /C8 Net-_D3-Pad1_ 330
R4 /C6 Net-_D4-Pad1_ 330
SP1 +3.3V Net-_D12-Pad1_ SPEAKER
R9 Net-_D12-Pad1_ Net-_Q1-Pad3_ 120
R8 Net-_Q1-Pad1_ /B9 10
D5 Net-_D5-Pad1_ GND LED
D6 Net-_D6-Pad1_ GND LED
R10 /D14 Net-_D5-Pad1_ 330
R11 /D12 Net-_D6-Pad1_ 330
D7 Net-_D7-Pad1_ GND LED
D8 Net-_D8-Pad1_ GND LED
R12 /D8 Net-_D7-Pad1_ 330
R13 /B15 Net-_D8-Pad1_ 330
D9 Net-_D9-Pad1_ GND LED
R14 +12V Net-_D9-Pad1_ 1.2k
Q1 Net-_Q1-Pad1_ GND Net-_Q1-Pad3_ NPN
P9 /CAN_L Net-_P9-Pad2_ CAN_JP
R15 /CAN_H Net-_P9-Pad2_ 120
R1 Net-_R1-Pad1_ GND 100k
P11 /C0 /C1 /C2 /C3 A/D
P13 GND +3.3V GND +3.3V GND +3.3V GND +3.3V CONN_02X04
P14 /D15 /D13 /D9 /B14 I/O
P15 GND +5V GND +5V GND +5V GND +5V CONN_02X04
U2 +3.3V /GP0 /GP1 Net-_R18-Pad1_ /D6 /D5 NC_20 NC_21 NC_22 NC_23 +3.3V /D- /D+ GND MCP2221
R18 Net-_R18-Pad1_ +3.3V 10k
P6 +5V /D- /D+ NC_24 GND NC_25 SERIAL1
R16 Net-_D10-Pad2_ GND 510
R17 Net-_D11-Pad2_ GND 510
D10 /GP0 Net-_D10-Pad2_ LED
D11 /GP1 Net-_D11-Pad2_ LED
C2 GND +3.3V 0.1u
P5 /E6 /E5 /A1 /A0 /A3 /A2 /A7 /A6 /B1 /B0 /E9 /E11 /E13 /E14 PWM
P16 /B8 /C9 PWM
D12 Net-_D12-Pad1_ +3.3V DIODE
P17 GND +5V /B10 /B11 SERIAL0
C5 +5V GND 0.1u
SW1 GND /E12 SW1
R2 +5V /E12 10k
C6 +12V GND 0.1u
C7 +5V GND 0.1u
U3 +12V GND +5V 78L05
.end
