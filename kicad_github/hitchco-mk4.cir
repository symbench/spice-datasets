.title KiCad schematic
J2 /GND1 /PSU1_12V OILL_SIG_PIN /SPED OILP_SIG_PIN FUEL_SIG_PIN ACT_SIG_PIN /BATC /EBRK /EGOL Screw_Terminal_01x10
J5 PB1_LED_EN NC_01 NC_02 PB1_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J7 PB2_LED_EN NC_03 NC_04 PB2_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J8 /hitchco-mk4/FLSHIN NC_05 NC_06 /PSU1_12V /hitchco-mk4/PB3_NO /GND1 Conn_02x03_Counter_Clockwise
J10 PB4_LED_EN NC_07 NC_08 PB4_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J12 PB6_LED_EN NC_09 NC_10 PB6_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J13 PB7_LED_EN NC_11 NC_12 PB7_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J15 PB9_LED_EN NC_13 NC_14 PB9_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J16 PB10_LED_EN NC_15 NC_16 PB10_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J18 PB11_LED_EN NC_17 NC_18 PB11_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J19 PB12_LED_EN NC_19 NC_20 PB12_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J24 PB15_LED_EN NC_21 NC_22 PB15_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J25 PB16_LED_EN NC_23 NC_24 PB16_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J26 PB17_LED_EN NC_25 NC_26 PB17_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J27 PB8_RLED_EN PB8_GLED_EN PB8_BLED_EN PB8_SIG_PIN /VIN_5V_ /VIN_5V_ Conn_02x03_Counter_Clockwise
J28 NC_27 NC_28 NC_29 PSU1_SIG_PIN /GND1 /hitchco-mk4/RS1_L1 Conn_02x03_Counter_Clockwise
J30 /PSU1_12V /PSU1_12V NC_30 NC_31 /hitchco-mk4/LED2- /hitchco-mk4/LED1- Conn_02x03_Counter_Clockwise
J1 /PSU1_12V /PSU1_GND /GND1 /VIN_5V_ /PSU1_12V /PSU2_GND /PSU1_12V /PSU3_GND /VIN_5V_ /VIN_5V_ Screw_Terminal_01x10
J4 /EGOR /RVRS ECT_SIG_PIN /HALR /HALL /ECF /DIRL /DIRR /STEN /RUEN Screw_Terminal_01x10
J6 /WIPEO /WIPEL /WIPEH /CRZR /CRZB /CRZG /CRZY /GND1 /GND1 /PSU1_12V Screw_Terminal_01x10
J22 PB14_LED_EN NC_32 NC_33 PB14_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
J21 PB13_LED_EN NC_34 NC_35 PB13_SIG_PIN /VIN_5V_ /GND1 Conn_02x03_Counter_Clockwise
SHIELD1 NC_36 NC_37 TACK_SIG_PIN SPED_SIG_PIN ECF_EN_PIN STEN_EN_PIN /VIN_5V_ RUEN_EN_PIN DIRL_EN_PIN DIRR_EN_PIN WIPEO_EN_PIN WIPEL_EN_PIN WIPEH_EN_PIN NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 /HALL /HALR NC_44 NC_45 PSU1_EN_PIN PSU2_EN_PIN PSU3_EN_PIN NC_46 SREG_SER_PIN SREG_RCLK_PIN SREG_SRCLK_PIN SREG_SRCLR_PIN SREG_OE_PIN MUX_S3_PIN MUX_S2_PIN MUX_S1_PIN MUX_S0_PIN MUX_EN_PIN NC_47 NC_48 NC_49 NC_50 CRZ_RESUME_PIN CRZ_MAINTAIN_PIN CRZ_DISABLE_PIN PB8_SIG_PIN PB8_BLED_EN PB8_GLED_EN PB8_RLED_EN LED2_EN_PIN LED1_EN_PIN NC_51 NC_52 NC_53 NC_54 NC_55 3V3 /VIN_5V_ /VIN_5V_ VBAT_SIG_PIN ECT_SIG_PIN ACT_SIG_PIN OILP_SIG_PIN FUEL_SIG_PIN OILL_SIG_PIN BATC_SIG_PIN EGOL_SIG_PIN EGOR_SIG_PIN EBRK_SIG_PIN RVRS_SIG_PIN PSU1_SIG_PIN MUX_SIG_PIN NC_56 NC_57 NC_58 NC_59 /GND1 /GND1 NC_60 /GND1 /GND1 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 ARDUINO_MEGA_SHIELD
Q28 /hitchco-mk4/NMOS1_B/DRAIN /DIRL /PSU1_12V Q_PMOS_GDS
R92 /hitchco-mk4/NMOS1_B/DRAIN /PSU1_12V 10KΩ
Q29 /hitchco-mk4/NMOS1_C/DRAIN /DIRR /PSU1_12V Q_PMOS_GDS
R93 /hitchco-mk4/NMOS1_C/DRAIN /PSU1_12V 10KΩ
Q11 /hitchco-mk4/NMOS1_D/DRAIN /PSU3_GND /PSU1_12V Q_PMOS_GDS
R54 /hitchco-mk4/NMOS1_D/DRAIN /PSU1_12V 10KΩ
Q2 /GND1 Net-_Q2-Pad2_ Net-_Q2-Pad3_ 2N3904
R41 Net-_Q2-Pad2_ WIPEO_EN_PIN 1KΩ
R43 Net-_R43-Pad1_ /WIPEO 560Ω
R42 /GND1 Net-_Q2-Pad2_ 10KΩ
R40 Net-_D6-Pad1_ /GND1 330Ω
D6 Net-_D6-Pad1_ WIPEO_EN_PIN LED
U1 Net-_R43-Pad1_ Net-_Q2-Pad3_ /WIPEO /WIPEL CPC1977
U7 Net-_R89-Pad1_ Net-_U7-Pad2_ Net-_U7-Pad13_ /GND1 Net-_U7-Pad2_ /GND1 /GND1 /hitchco-mk4/PB3_NC /GND1 /hitchco-mk4/PB3_NO /GND1 NC_73 Net-_U7-Pad13_ /PSU1_12V CD4013B
D16 /hitchco-mk4/FLSHIN /DIRL DIODE
D17 /hitchco-mk4/FLSHIN /DIRR DIODE
Q13 Net-_Q13-Pad1_ NC_74 /PSU1_12V Q_PMOS_GDS
R90 /hitchco-mk4/PB3_NO /GND1 1KΩ
R91 /hitchco-mk4/PB3_NC /GND1 1KΩ
R89 Net-_R89-Pad1_ Net-_Q13-Pad1_ 10KΩ
R9 /PSU1_12V VBAT_SIG_PIN 100KΩ
R10 VBAT_SIG_PIN /GND1 51KΩ
C1 /PSU1_12V /GND1 0.1UF
R11 /VIN_5V_ OILP_SIG_PIN 43Ω
C2 /VIN_5V_ /GND1 0.1UF
R12 /VIN_5V_ FUEL_SIG_PIN 46.4Ω
C3 /VIN_5V_ /GND1 0.1UF
R14 BATC_SIG_PIN /GND1 105KΩ
R13 /BATC BATC_SIG_PIN 100KΩ
C4 /BATC /GND1 0.1UF
U2 EGOL_SIG_PIN Net-_R15-Pad2_ /EGOL /GND1 /EGOR EGOL_SIG_PIN EGOR_SIG_PIN /VIN_5V_ LM358
R15 EGOL_SIG_PIN Net-_R15-Pad2_ 10KΩ
R17 /GND1 Net-_R15-Pad2_ 4.3KΩ
R16 EGOR_SIG_PIN EGOL_SIG_PIN 10KΩ
R18 /GND1 EGOL_SIG_PIN 4.3KΩ
C5 /EGOL /GND1 0.01UF
C6 /EGOR /GND1 0.01UF
C7 ACT_SIG_PIN /GND1 0.1UF
R21 /EBRK EBRK_SIG_PIN 100KΩ
R22 EBRK_SIG_PIN /GND1 51KΩ
C8 /EBRK /GND1 0.1UF
R23 /RVRS RVRS_SIG_PIN 100KΩ
R24 RVRS_SIG_PIN /GND1 51KΩ
C9 /RVRS /GND1 0.1UF
R26 DIRR_EN_PIN /GND1 10KΩ
D1 Net-_D1-Pad1_ DIRR_EN_PIN LED
R25 Net-_D1-Pad1_ /GND1 330Ω
Q1 DIRR_EN_PIN /hitchco-mk4/NMOS1_C/DRAIN /GND1 Q_NMOS_GDS
R28 DIRL_EN_PIN /GND1 10KΩ
D2 Net-_D2-Pad1_ DIRL_EN_PIN LED
R27 Net-_D2-Pad1_ /GND1 330Ω
Q5 DIRL_EN_PIN /hitchco-mk4/NMOS1_B/DRAIN /GND1 Q_NMOS_GDS
C10 ECT_SIG_PIN /GND1 0.1UF
Q8 /GND1 Net-_Q8-Pad2_ Net-_Q6-Pad1_ 2N3904
R30 Net-_Q8-Pad2_ STEN_EN_PIN 1KΩ
R29 /PSU1_12V Net-_Q6-Pad1_ 10KΩ
R31 /GND1 Net-_Q8-Pad2_ 10KΩ
R32 Net-_D3-Pad1_ /GND1 330Ω
D3 Net-_D3-Pad1_ STEN_EN_PIN LED
Q6 Net-_Q6-Pad1_ /STEN /PSU1_12V Q_PMOS_GDS
Q10 /GND1 Net-_Q10-Pad2_ Net-_Q10-Pad3_ 2N3904
R34 Net-_Q10-Pad2_ RUEN_EN_PIN 1KΩ
R33 /PSU1_12V Net-_Q10-Pad3_ 10KΩ
R35 /GND1 Net-_Q10-Pad2_ 10KΩ
R36 Net-_D4-Pad1_ /GND1 330Ω
D4 Net-_D4-Pad1_ RUEN_EN_PIN LED
Q7 Net-_Q10-Pad3_ /RUEN /PSU1_12V Q_PMOS_GDS
R37 OILL_SIG_PIN /VIN_5V_ 10KΩ
C11 OILL_SIG_PIN /GND1 0.1UF
R39 ECF_EN_PIN /GND1 10KΩ
D5 Net-_D5-Pad1_ ECF_EN_PIN LED
R38 Net-_D5-Pad1_ /GND1 330Ω
Q9 ECF_EN_PIN /ECF /GND1 Q_NMOS_GDS
Q15 /GND1 Net-_Q15-Pad2_ Net-_Q12-Pad1_ 2N3904
R45 Net-_Q15-Pad2_ WIPEL_EN_PIN 1KΩ
R44 /PSU1_12V Net-_Q12-Pad1_ 10KΩ
R46 /GND1 Net-_Q15-Pad2_ 10KΩ
R47 Net-_D7-Pad1_ /GND1 330Ω
D7 Net-_D7-Pad1_ WIPEL_EN_PIN LED
Q12 Net-_Q12-Pad1_ /WIPEL /PSU1_12V Q_PMOS_GDS
Q17 /GND1 Net-_Q17-Pad2_ Net-_Q14-Pad1_ 2N3904
R49 Net-_Q17-Pad2_ WIPEH_EN_PIN 1KΩ
R48 /PSU1_12V Net-_Q14-Pad1_ 10KΩ
R50 /GND1 Net-_Q17-Pad2_ 10KΩ
R51 Net-_D8-Pad1_ /GND1 330Ω
D8 Net-_D8-Pad1_ WIPEH_EN_PIN LED
Q14 Net-_Q14-Pad1_ /WIPEH /PSU1_12V Q_PMOS_GDS
R52 /GND1 PB1_SIG_PIN 10K
R53 /GND1 PB2_SIG_PIN 10K
R55 /GND1 PB9_SIG_PIN 10K
R56 /GND1 PB10_SIG_PIN 10K
R57 /GND1 PB14_SIG_PIN 10K
R58 /GND1 PB15_SIG_PIN 10K
R59 /GND1 PB16_SIG_PIN 10K
R60 /GND1 PB17_SIG_PIN 10K
R61 /GND1 PB4_SIG_PIN 10K
R62 /GND1 PB6_SIG_PIN 10K
R63 /GND1 PB7_SIG_PIN 10K
R64 /GND1 PB11_SIG_PIN 10K
R65 /GND1 PB12_SIG_PIN 10K
R66 /GND1 PB13_SIG_PIN 10K
R67 /GND1 PB8_SIG_PIN 10K
R69 PSU2_EN_PIN /GND1 10KΩ
D9 Net-_D9-Pad1_ PSU2_EN_PIN LED
R68 Net-_D9-Pad1_ /GND1 330Ω
Q16 PSU2_EN_PIN /PSU2_GND /GND1 Q_NMOS_GDS
R71 PSU3_EN_PIN /GND1 10KΩ
D10 Net-_D10-Pad1_ PSU3_EN_PIN LED
R70 Net-_D10-Pad1_ /GND1 330Ω
Q18 PSU3_EN_PIN /hitchco-mk4/NMOS1_D/DRAIN /GND1 Q_NMOS_GDS
R73 LED1_EN_PIN /GND1 10KΩ
D11 Net-_D11-Pad1_ LED1_EN_PIN LED
R72 Net-_D11-Pad1_ /GND1 330Ω
Q19 LED1_EN_PIN /hitchco-mk4/LED1- /GND1 Q_NMOS_GDS
R75 LED2_EN_PIN /GND1 10KΩ
D12 Net-_D12-Pad1_ LED2_EN_PIN LED
R74 Net-_D12-Pad1_ /GND1 330Ω
Q20 LED2_EN_PIN /hitchco-mk4/LED2- /GND1 Q_NMOS_GDS
Q23 /GND1 Net-_Q23-Pad2_ Net-_Q21-Pad1_ 2N3904
R77 Net-_Q23-Pad2_ CRZ_DISABLE_PIN 1KΩ
R76 /CRZR Net-_Q21-Pad1_ 10KΩ
R78 /GND1 Net-_Q23-Pad2_ 10KΩ
R79 Net-_D13-Pad1_ /GND1 330Ω
D13 Net-_D13-Pad1_ CRZ_DISABLE_PIN LED
Q21 Net-_Q21-Pad1_ /CRZB /CRZR Q_PMOS_GDS
Q25 /GND1 Net-_Q25-Pad2_ Net-_Q22-Pad1_ 2N3904
R81 Net-_Q25-Pad2_ CRZ_MAINTAIN_PIN 1KΩ
R80 /CRZR Net-_Q22-Pad1_ 10KΩ
R82 /GND1 Net-_Q25-Pad2_ 10KΩ
R83 Net-_D14-Pad1_ /GND1 330Ω
D14 Net-_D14-Pad1_ CRZ_MAINTAIN_PIN LED
Q22 Net-_Q22-Pad1_ /CRZG /CRZR Q_PMOS_GDS
Q27 /GND1 Net-_Q27-Pad2_ Net-_Q24-Pad1_ 2N3904
R85 Net-_Q27-Pad2_ CRZ_RESUME_PIN 1KΩ
R84 /CRZR Net-_Q24-Pad1_ 10KΩ
R86 /GND1 Net-_Q27-Pad2_ 10KΩ
R87 Net-_D15-Pad1_ /GND1 330Ω
D15 Net-_D15-Pad1_ CRZ_RESUME_PIN LED
Q24 Net-_Q24-Pad1_ /CRZY /CRZR Q_PMOS_GDS
U4 PB2_LED_EN NC_75 PB4_LED_EN PB6_LED_EN PB7_LED_EN PB9_LED_EN PB10_LED_EN /GND1 Net-_U4-Pad9_ SREG_SRCLR_PIN SREG_SRCLK_PIN SREG_RCLK_PIN SREG_OE_PIN SREG_SER_PIN PB1_LED_EN /VIN_5V_ 74HC595
U5 PB12_LED_EN PB13_LED_EN PB14_LED_EN PB15_LED_EN PB16_LED_EN PB17_LED_EN NC_76 /GND1 NC_77 SREG_SRCLR_PIN SREG_SRCLK_PIN SREG_RCLK_PIN SREG_OE_PIN Net-_U4-Pad9_ PB11_LED_EN /VIN_5V_ 74HC595
U6 MUX_SIG_PIN PB10_SIG_PIN PB9_SIG_PIN PB7_SIG_PIN PB6_SIG_PIN PB4_SIG_PIN NC_78 PB2_SIG_PIN PB1_SIG_PIN MUX_S0_PIN MUX_S1_PIN /GND1 MUX_S3_PIN MUX_S2_PIN MUX_EN_PIN NC_79 PB17_SIG_PIN PB16_SIG_PIN PB15_SIG_PIN PB14_SIG_PIN PB13_SIG_PIN PB12_SIG_PIN PB11_SIG_PIN /VIN_5V_ CD74HC4067
R88 MUX_EN_PIN /GND1 10KΩ
C12 /VIN_5V_ /GND1 0.1UF
R1 /PSU1_12V Net-_Q3-Pad3_ 3.4KΩ
R4 /hitchco-mk4/RS1_L1 Net-_Q3-Pad3_ 10KΩ
Q3 /GND1 Net-_Q3-Pad2_ Net-_Q3-Pad3_ 2N3904
R6 Net-_Q4-Pad3_ Net-_Q3-Pad2_ 10KΩ
R2 /PSU1_12V Net-_Q4-Pad3_ 3.4KΩ
Q4 /GND1 /hitchco-mk4/RS1_L1 Net-_Q4-Pad3_ 2N3904
R3 Net-_Q26-Pad1_ Net-_Q4-Pad3_ 10KΩ
R7 Net-_Q26-Pad1_ /GND1 10KΩ
R8 PSU1_SIG_PIN /VIN_5V_ 10KΩ
R5 Net-_Q3-Pad2_ PSU1_EN_PIN 10KΩ
Q26 Net-_Q26-Pad1_ /PSU1_GND /GND1 Q_NMOS_GDS
U3 TACK_SIG_PIN SPED_SIG_PIN /VIN_5V_ Net-_RV1-Pad2_ Net-_D18-PadK_ 3V3 NC_80 NC_81 NC_82 NC_83 NC_84 /GND1 NC_85 NC_86 LM339
R20 /VIN_5V_ SPED_SIG_PIN 10KΩ
R19 /VIN_5V_ Net-_R19-Pad2_ 15KΩ
RV1 Net-_R19-Pad2_ Net-_RV1-Pad2_ /GND1 10KΩ
D18 /GND1 Net-_D18-PadK_ DIODE
R94 /SPED Net-_D18-PadK_ 10KΩ
C14 TACK_SIG_PIN /GND1 C
C13 SPED_SIG_PIN /GND1 C
R95 /VIN_5V_ TACK_SIG_PIN 10KΩ
.end
