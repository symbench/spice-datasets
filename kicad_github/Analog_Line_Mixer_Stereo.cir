.title KiCad schematic
J1 GND Net-_J1-Pad2_ Net-_J1-Pad3_ IN-1
J2 GND Net-_J2-Pad2_ Net-_J2-Pad3_ IN-2
J3 GND Net-_J3-Pad2_ Net-_J3-Pad3_ IN-3
J4 GND Net-_J4-Pad2_ Net-_J4-Pad3_ IN-4
RV1 Net-_R8-Pad1_ /RSUM GND Net-_R2-Pad1_ /LSUM GND 100K
RV2 Net-_R3-Pad1_ /RSUM GND Net-_R1-Pad1_ /LSUM GND 100K
RV3 Net-_R4-Pad1_ /RSUM GND Net-_R5-Pad1_ /LSUM GND 100K
RV4 Net-_R6-Pad1_ /RSUM GND Net-_R7-Pad1_ /LSUM GND 100K
R8 Net-_R8-Pad1_ Net-_J1-Pad3_ 10K
R2 Net-_R2-Pad1_ Net-_J1-Pad2_ 10K
R3 Net-_R3-Pad1_ Net-_J2-Pad3_ 10K
R1 Net-_R1-Pad1_ Net-_J2-Pad2_ 10K
R4 Net-_R4-Pad1_ Net-_J3-Pad3_ 10K
R5 Net-_R5-Pad1_ Net-_J3-Pad2_ 10K
R6 Net-_R6-Pad1_ Net-_J4-Pad3_ 10K
R7 Net-_R7-Pad1_ Net-_J4-Pad2_ 10K
C2 Net-_C2-Pad1_ /LSUM 1uF
C1 Net-_C1-Pad1_ /RSUM 1uF
U1 Net-_C5-Pad1_ Net-_C2-Pad1_ /+B GND /+B Net-_C1-Pad1_ Net-_C4-Pad1_ VCC RC4560
D2 Net-_D2-Pad1_ +12V 1N4001
C3 VCC GND 1000uF
R9 Net-_R9-Pad1_ VCC 2k
SW1 Net-_R9-Pad1_ Net-_D3-Pad2_ POWER_TEST
D3 GND Net-_D3-Pad2_ POWER_TEST
R11 VCC /+B 18k
R13 /+B GND 22k
C6 /+B GND 47uF
C5 Net-_C5-Pad1_ Net-_C2-Pad1_ 27pF
R12 Net-_C2-Pad1_ Net-_C5-Pad1_ 100k
C4 Net-_C4-Pad1_ Net-_C1-Pad1_ 27pF
R10 Net-_C1-Pad1_ Net-_C4-Pad1_ 100k
R14 Net-_C5-Pad1_ Net-_C8-Pad1_ 100
R15 Net-_C4-Pad1_ Net-_C7-Pad1_ 100
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ 47uF
C7 Net-_C7-Pad1_ Net-_C7-Pad2_ 47uF
J5 GND Net-_C8-Pad2_ Net-_C7-Pad2_ OUT
P1 /Power_Regulator/Vin NC_01 NC_02 GND GND USB_B
D1 Net-_D1-Pad1_ Net-_CON1-Pad1_ 1N4001
CON1 Net-_CON1-Pad1_ GND GND BARREL_JACK
SW2 Net-_D1-Pad1_ VCC Net-_D2-Pad1_ Power Selector
U2 Net-_R16-Pad1_ Net-_R17-Pad1_ NC_03 GND Net-_D4-Pad2_ /Power_Regulator/Vin GND GND LM2698
L1 Net-_D4-Pad2_ /Power_Regulator/Vin 10uH
C9 /Power_Regulator/Vin GND 22uF, 10V
C11 Net-_C11-Pad1_ GND 4.7nF
R16 Net-_R16-Pad1_ Net-_C11-Pad1_ 24k9
R18 +12V Net-_R17-Pad1_ 30k1
R17 Net-_R17-Pad1_ GND 3k48
C10 GND +12V 10uF
D4 +12V Net-_D4-Pad2_ D_Schottky
.end
