.title KiCad schematic
D4 TX_LED Net-_D4-Pad2_ Orange
D5 RX_LED Net-_D5-Pad2_ Yellow
R10 EN_IR_BUS GND 10k
U7 +3V3 SYS-TX SYS-RX NC_01 TX_ACTIVE GND NC_02 NC_03 NC_04 NC_05 Net-_C19-Pad2_ EN_IR_BUS TXB0104RUT
JP2 NC_06 GND +3V3 SolderJumper_3_Bridged12
C20 GND +3V3 0.1uF
C19 GND Net-_C19-Pad2_ 0.1uF
C18 +3V3 GND 0.1uF
C17 GND Net-_C17-Pad2_ 0.1uF
J5 +3V3 SWDIO GND SWCLK GND NC_07 NC_08 NC_09 NC_10 RST Conn_ARM_JTAG_SWD_10
R12 Net-_D4-Pad2_ +3V3 330
R14 Net-_D5-Pad2_ +3V3 330
J3 NC_11 USB_D- USB_D+ NC_12 GND GND GND GND GND UX60-MB-5ST
R9 EN_IR_BUS GND 10k
U4 NC_13 NC_14 NC_15 NC_16 Net-_C17-Pad2_ EN_IR_BUS NC_17 NC_18 NC_19 NC_20 IO-TX IO-RX IO-CTS IO-DSR GND +3V3 IO-RTS IO-DCD IO-RI IO-DTR TXB0108DQSR
J4 +3V3 Net-_C19-Pad2_ +5V GND Conn_01x03
R18 +3V3 SWCLK 1k
C29 RST GND 100nF
SW1 GND Net-_R17-Pad1_ RESET
R17 Net-_R17-Pad1_ RST 330
R15 +3V3 RST 10k
U5 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 GND +3V3 NC_30 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 NC_39 NC_40 GND Net-_U5-Pad25_ FLASH_MOSI FLASH_SCK FLASH_CS FLASH_MISO Net-_U5-Pad25_ GND IO-DTR NC_41 NC_42 NC_43 NC_44 NC_45 GND +3V3 NC_46 NC_47 NC_48 NC_49 EN_IR_BUS TX_ACTIVE IO-CTS NC_50 IO-DSR IO-RTS GND +3V3 IO-DCD NC_51 IO-TX IO-RX NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 GND +3V3 NC_58 NC_59 IO-RI NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 USB_D- USB_D+ GND +3V3 SYS-TX SYS-RX NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 TX_LED RST VDDCORE GND VSW +3V3 SWCLK SWDIO NC_74 NC_75 NC_76 NC_77 NC_78 RX_LED SAMD51
R16 +3V3 FLASH_CS 10k
C21 +3V3 GND 10uF
C22 +3V3 GND 10uF
C23 +3V3 GND 10uF
C24 +3V3 GND 10uF
C25 +3V3 GND 10uF
C26 +3V3 GND 100nF
C27 VDDCORE GND 4.7uF
C28 VDDCORE GND 100nF
L2 VDDCORE VSW 10uH
U6 FLASH_CS FLASH_MISO FLASH_CS GND FLASH_MOSI FLASH_SCK FLASH_CS +3V3 AT25DF041B-SSHN-T
.end
