.title KiCad schematic
C321 PP_DRAM COM 0.22u
C319 PP_DRAM COM 0.22u
C317 PP_DRAM COM 0.22u
C322 PP_DRAM COM 0.22u
C320 PP_DRAM COM 0.22u
C318 PP_DRAM COM 0.22u
C323 PP_DRAM COM 10u
R304 PP_DRAM DRAM_VREF 1.5k
R306 DRAM_VREF COM 1.5k
C324 PP_DRAM DRAM_VREF 0.22u
C330 DRAM_VREF COM 0.22u
C325 PP_DRAM COM 10u
C304 DRAM_VREF COM 0.22u
C303 PP_VDD_HIGH_CAP COM 0.22u
R303 /~DRAM_RESET COM 10k
R302 Net-_R302-Pad1_ COM 240
U301 PP_DRAM /DRAM_DQ13 /DRAM_DQ15 /DRAM_DQ12 PP_DRAM COM COM PP_DRAM COM /~DRAM_UDQS /DRAM_DQ14 COM PP_DRAM /DRAM_DQ11 /DRAM_DQ9 /DRAM_UDQS /DRAM_DQ10 PP_DRAM COM PP_DRAM /DRAM_UDM /DRAM_DQ8 COM PP_DRAM COM COM /DRAM_DQ0 /DRAM_LDM COM PP_DRAM PP_DRAM /DRAM_DQ2 /DRAM_LDQS /DRAM_DQ1 /DRAM_DQ3 COM COM /DRAM_DQ6 /~DRAM_LDQS PP_DRAM COM COM DRAM_VREF PP_DRAM /DRAM_DQ4 /DRAM_DQ7 /DRAM_DQ5 PP_DRAM COM /~DRAM_RAS /DRAM_CK COM /DRAM_ODT PP_DRAM /~DRAM_CAS /~DRAM_CK PP_DRAM /DRAM_CKE /~DRAM_CS /~DRAM_WE /DRAM_A10 Net-_R301-Pad1_ COM /DRAM_BA0 /DRAM_BA2 DRAM_VREF COM PP_DRAM /DRAM_A3 /DRAM_A0 /DRAM_A12 /DRAM_BA1 PP_DRAM COM /DRAM_A5 /DRAM_A2 /DRAM_A1 /DRAM_A4 COM PP_DRAM /DRAM_A7 /DRAM_A9 /DRAM_A11 /DRAM_A6 PP_DRAM COM /~DRAM_RESET /DRAM_A13 /DRAM_A14 /DRAM_A8 COM MT41K256M16-107
U201 NC_01 /DRAM_A14 /DRAM_A6 /~DRAM_RESET PP_DRAM /DRAM_BA1 /DRAM_A1 /DRAM_A13 /DRAM_A7 NC_02 PP_DRAM /~DRAM_WE /~DRAM_CAS NC_03 /DRAM_A8 PP_DRAM /DRAM_A2 /DRAM_BA2 /DRAM_A11 /DRAM_A4 NC_04 PP_DRAM /DRAM_A5 /DRAM_A9 /DRAM_A12 /DRAM_A0 PP_DRAM /DRAM_BA0 /DRAM_A3 /DRAM_CKE /DRAM_A10 /~DRAM_RAS PP_DRAM /DRAM_ODT /~DRAM_CS Net-_R302-Pad1_ PP_VDD_HIGH_CAP /DRAM_CK /~DRAM_CK /DRAM_DQ13 DRAM_VREF /DRAM_DQ12 /DRAM_LDQS /~DRAM_LDQS /DRAM_DQ15 /DRAM_DQ14 /DRAM_DQ11 /DRAM_UDQS /~DRAM_UDQS /DRAM_UDM /DRAM_DQ0 /DRAM_DQ6 /DRAM_DQ2 /DRAM_LDM /DRAM_DQ5 /DRAM_DQ8 /DRAM_DQ9 /DRAM_DQ7 /DRAM_DQ10 /DRAM_DQ1 /DRAM_DQ3 /DRAM_DQ4 MCIMX6Y2DVM
R301 Net-_R301-Pad1_ COM 240
C302 DRAM_VREF COM 0.22u
C301 DRAM_VREF COM 0.22u
C310 PP_DRAM COM 0.22u
C308 PP_DRAM COM 0.22u
C306 PP_DRAM COM 0.22u
C309 PP_DRAM COM 0.22u
C307 PP_DRAM COM 0.22u
C305 PP_DRAM COM 22u
R305 /DRAM_CK /~DRAM_CK 470
C326 /DRAM_LDQS /~DRAM_LDQS 2.2p
C327 /DRAM_LDQS /~DRAM_LDQS 2.2p
C328 /DRAM_UDQS /~DRAM_UDQS 2.2p
C329 /DRAM_UDQS /~DRAM_UDQS 2.2p
TP302 /DRAM_A0 A0
TP301 /DRAM_A0 A0
TP309 /DRAM_DQ0 DQ0
TP308 /DRAM_DQ0 DQ0
TP304 /DRAM_CK CK
TP303 /DRAM_CK CK
TP306 /~DRAM_CK ~CK
TP305 /~DRAM_CK ~CK
TP310 COM GND
TP312 COM GND
TP311 COM GND
TP307 COM GND
C315 PP_DRAM COM 0.22u
C313 PP_DRAM COM 0.22u
C311 PP_DRAM COM 0.22u
C314 PP_DRAM COM 0.22u
C312 PP_DRAM COM 0.22u
C316 PP_DRAM COM 0.22u
.end
