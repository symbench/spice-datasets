.title KiCad schematic
U2 +3.3V /RA5 /RA4 /~MCLR /RC5 /RC4 /RC3 /RC6 /RC7 /RB7 /RB6 /RB5 /RB4 /RC2 /RC1 /RC0 Net-_C9-Pad2_ /D-_micro /D+_micro GND PIC16F1459_SOIC
U1 /RB5 NC_01 /+3.3V_ftdi /RB7 GND NC_02 Net-_R10-Pad1_ /D+_ftdi /D-_ftdi /+3.3V_ftdi Net-_R1-Pad2_ /+3.3V_ftdi GND Net-_R9-Pad1_ Net-_R8-Pad1_ Net-_R11-Pad1_ FT230XS
CON1 NC_03 /D- /D+ NC_04 GND NC_05 NC_06 NC_07 NC_08 USB-MINI-B
U3 GND +3.3V Vin +3.3V TLV1117_3.3V
C7 GND Vin CAP_0805
C8 GND +3.3V CAP_0805
R2 +3.3V /+3.3V_ftdi RES_0603
C4 GND /+3.3V_ftdi CAP_0603
C2 GND /+3.3V_ftdi CAP_0603
C1 GND /+3.3V_ftdi CAP_0805
C3 GND /D- CAP_0603
C5 GND /D+ CAP_0603
R7 /D+ /D+_ftdi RES_0603
R6 /D+ /D+_micro RES_0603
R5 /D- /D-_ftdi RES_0603
R4 /D- /D-_micro RES_0603
R3 GND Net-_R1-Pad2_ RES_0603
C6 GND +3.3V CAP_0603
C9 GND Net-_C9-Pad2_ CAP_0603
R28 Net-_C9-Pad2_ +3.3V RES_0603
R1 /+3.3V_ftdi Net-_R1-Pad2_ RES_0603
J1 /~MCLR Net-_J1-Pad2_ GND /ICSPDAT /ICSPCLK NC_09 HEADER_1X6
R25 +3.3V Net-_J1-Pad2_ RES_0603
R24 /~MCLR NC_10 RES_0603
R26 /RC0 /ICSPDAT RES_0603
R27 /RC1 /ICSPCLK RES_0603
SW2 /~MCLR GND SWITCH_MOMENTARY
SW1 GND Net-_R1-Pad2_ SWITCH_MOMENTARY
R8 Net-_R8-Pad1_ Net-_D3-PadC_ RES_0603
R9 Net-_R9-Pad1_ Net-_D4-PadC_ RES_0603
R10 Net-_R10-Pad1_ Net-_D5-PadC_ RES_0603
R11 Net-_R11-Pad1_ Net-_D6-PadC_ RES_0603
D3 +3.3V Net-_D3-PadC_ LED_0603
D4 +3.3V Net-_D4-PadC_ LED_0603
D5 +3.3V Net-_D5-PadC_ LED_0603
D6 +3.3V Net-_D6-PadC_ LED_0603
D9 +3.3V Net-_D9-PadC_ LED_0603
R29 GND Net-_D9-PadC_ RES_0603
R14 /RC2 +3.3V RES_0603
R19 NC_11 /RA4 RES_0603
R15 /RC3 +3.3V RES_0603
R20 NC_12 /RA5 RES_0603
Q1 NC_13 /RC0 +3.3V MOSFET-P
R12 /RC0 +3.3V RES_0603
R13 /RC1 +3.3V RES_0603
R17 /RC5 +3.3V RES_0603
R22 NC_14 /RB6 RES_0603
R18 /RC6 +3.3V RES_0603
R21 NC_15 /RB4 RES_0603
R16 /RC4 +3.3V RES_0603
R23 NC_16 /RC7 RES_0603
Q2 NC_17 /RC1 +3.3V MOSFET-P
Q3 NC_18 /RC2 +3.3V MOSFET-P
Q4 NC_19 /RC3 +3.3V MOSFET-P
Q7 NC_20 /RC6 +3.3V MOSFET-P
Q6 NC_21 /RC5 +3.3V MOSFET-P
Q5 NC_22 /RC4 +3.3V MOSFET-P
P1 +3.3V GND /RA5 NC_23 /RA4 NC_24 /~MCLR NC_25 /RC5 /RC0 /RC4 /RC1 /RC3 /RC2 /RC6 /RB4 /RC7 /RB5 /RB7 /RB6 CONN_10X2
CON2 NC_26 GND GND BARREL_JACK
M1 GND MNT-3MM
M2 GND MNT-3MM
M3 GND MNT-3MM
M4 GND MNT-3MM
.end
